/**************************************************************************************
 *
 * spi.c
 *
 * Contains the source code for communicating
 * with the MAX7456 using a bit-banged SPI port
**************************************************************************************/

// INCLUDES ***********************************************
#include <spi.h>

#include "microcontroller/microcontroller.h"
#include "max7456/max7456.h"
                                          // SPI ports defined using macros to enable pins to be changed around as required
#define SPI_CS      PORTBbits.RB2          // PO5_bit.bit4 = /CS - chip select
#define SPI_MOSI    PORTFbits.RF7          // PO5_bit.bit5 = MOSI - master out slave in, data to MAX7456
#define SPI_MISO    PORTFbits.RF8          // PO5_bit.bit7 = MISO - master in slave out, data from MAX7456
#define SPI_CK      PORTFbits.RF6          // PO5_bit.bit6 = SCK - SPI clock


// VARIABLES **********************************************

volatile unsigned char data[DATA_BUF_LENGTH];
extern const char *chars[] ;






void max7456_init()
{
	TRISFbits.TRISF7 = 0;	// make this an output MOSI
	TRISFbits.TRISF8 = 1;	// make this an input MISO
	TRISFbits.TRISF6 = 0;	// make this an output CSK 
	TRISBbits.TRISB2 = 0;   // SS1
/*
    OpenSPI1(ENABLE_SCK_PIN & ENABLE_SDO_PIN & SPI_MODE16_OFF & SPI_SMP_OFF & SPI_CKE_OFF &
         SLAVE_ENABLE_OFF & MASTER_ENABLE_ON & PRI_PRESCAL_64_1 & SEC_PRESCAL_8_1,
         FRAME_ENABLE_OFF,
         SPI_ENABLE & SPI_RX_OVFLOW_CLR);

	microcontroller_delay_ms(90);*/
}	


int max756_read_status()
{
	return spiReadReg(STATUS_READ);
}	


void max7456_loadchars()
{
	int i, j;
	
	for (i = 0; i < 256; i++)
	{
		for (j = 0; j < 56; j++)
		{
			data[j+2] = chars[i][j];
		}	
		data[1] = (unsigned char) i;
			spiWriteFM();
	}	
	
}	


/**************************************************************************************
 * spiWriteReg
 *
 * Writes to an 8-bit register with the SPI port
 **************************************************************************************/

void spiWriteReg(const unsigned char regAddr, const unsigned char regData)
{

  unsigned char SPICount;                               // Counter used to clock out the data

  unsigned char SPIData;                                // Define a data structure for the SPI data.

  SPI_CS = 1;                                           // Make sure we start with /CS high
  SPI_CK = 0;                                           // and CK low

  SPIData = regAddr;                                    // Preload the data to be sent with Address
  SPI_CS = 0;                                           // Set /CS low to start the SPI cycle 25nS
                                                        // Although SPIData could be implemented as an "int", resulting in one
                                                        // loop, the routines run faster when two loops are implemented with
                                                        // SPIData implemented as two "char"s.
  
  for (SPICount = 0; SPICount < 8; SPICount++)          // Prepare to clock out the Address byte
  {
    if (SPIData & 0x80)                                 // Check for a 1
      SPI_MOSI = 1;                                     // and set the MOSI line appropriately
    else
      SPI_MOSI = 0;
    SPI_CK = 1;                                         // Toggle the clock line
    SPI_CK = 0;
    SPIData <<= 1;                                      // Rotate to get the next bit

  }                                                     // and loop back to send the next bit
                                                        // Repeat for the Data byte
  SPIData = regData;                                    // Preload the data to be sent with Data
  for (SPICount = 0; SPICount < 8; SPICount++)          // Prepare to clock out the Data
  {
    if (SPIData & 0x80)
      SPI_MOSI = 1;
    else
      SPI_MOSI = 0;
    SPI_CK = 1;
    SPI_CK = 0;
    SPIData <<= 1;
  }          
  SPI_CS = 1;
  SPI_MOSI = 0;
  /*

    while(SPI1STATbits.SPITBF) ;

	int i = SPI1BUF;

	SPI_CS = 0;
	microcontroller_delay_us(10);

	SPI1BUF = regAddr;
	while(SPI1STATbits.SPITBF) ;
	while(! SPI1STATbits.SPIRBF) ;
	microcontroller_delay_us(1);
	i = SPI1BUF;

	SPI1BUF = regData;
	while(SPI1STATbits.SPITBF) ;
	while(! SPI1STATbits.SPIRBF) ;
	microcontroller_delay_us(1);
	SPI_CS = 1;
   */
}

/**************************************************************************************
 * spiWriteRegAutoIncr
 *
 * Writes to an 8-bit register with the SPI port
 * using the MAX7456's auto-increment mode
 **************************************************************************************/

void spiWriteRegAutoIncr(const unsigned char regData)
{
  unsigned char SPICount;                               // Counter used to clock out the data
  
  unsigned char SPIData;                                // Define a data structure for the SPI data.
  
  SPI_CS = 1;                                           // Make sure we start with /CS high
  SPI_CK = 0;                                           // and CK low
  SPIData = regData;                                    // Preload the data to be sent with Address & Data

  SPI_CS = 0;                                           // Set /CS low to start the SPI cycle
  for (SPICount = 0; SPICount < 8; SPICount++)          // Prepare to clock out the Address & Data
  {
    if (SPIData & 0x80)
      SPI_MOSI = 1;
    else
      SPI_MOSI = 0;
    SPI_CK = 1;
    SPI_CK = 0;
    SPIData <<= 1;
  }                                                     // and loop back to send the next bit   
  SPI_MOSI = 0;                                         // Reset the MOSI data line
}

/**************************************************************************************
 * spiReadReg
 *
 * Reads an 8-bit register with the SPI port.
 * Data is returned. 
 **************************************************************************************/

unsigned char spiReadReg (const unsigned char regAddr)
{

  unsigned char SPICount;                               // Counter used to clock out the data
  
  unsigned char SPIData;                  
  
  SPI_CS = 1;                                           // Make sure we start with /CS high
  SPI_CK = 0;                                           // and CK low
  SPIData = regAddr;                                    // Preload the data to be sent with Address & Data

  SPI_CS = 0;                                           // Set /CS low to start the SPI cycle
  for (SPICount = 0; SPICount < 8; SPICount++)          // Prepare to clock out the Address & Data
  {
    if (SPIData & 0x80)
      SPI_MOSI = 1;
    else
      SPI_MOSI = 0;
    SPI_CK = 1;
    SPI_CK = 0;
    SPIData <<= 1;
  }                                                     // and loop back to send the next bit   
  SPI_MOSI = 0;                                         // Reset the MOSI data line
  
  SPIData = 0;
  for (SPICount = 0; SPICount < 8; SPICount++)          // Prepare to clock in the data to be fread
  {
    SPIData <<=1;                                       // Rotate the data
    SPI_CK = 1;                                         // Raise the clock to clock the data out of the MAX7456
    SPIData += SPI_MISO;                                // Read the data bit
    SPI_CK = 0;                                         // Drop the clock ready for th enext bit
  }                                                     // and loop back
  SPI_CS = 1;                                           // Raise CS   
                      
  return ((unsigned char)SPIData);                      // Finally return the read data


/*
    while(SPI1STATbits.SPITBF) ;

	int i = SPI1BUF;

	SPI_CS = 0;
	microcontroller_delay_us(10);

	SPI1BUF = regAddr;
	while(SPI1STATbits.SPITBF) ;
	while(! SPI1STATbits.SPIRBF) ;
	microcontroller_delay_us(1);
	i = SPI1BUF;

	SPI1BUF = 0x00;
	while(SPI1STATbits.SPITBF) ;
	while(! SPI1STATbits.SPIRBF) ;
	microcontroller_delay_us(1);
	SPI_CS = 1;
    return SPI1BUF;*/
}

/**************************************************************************************
 * spiWriteCM
 *
 * Writes to the Display Memory (960 bytes) from "data" extern.
 * 960 = 16 rows * 30 columns * 2 planes {char vs attr} screen-position-indexed memory
 **************************************************************************************/

void spiWriteCM()                                       // On entry: global data[1..960] contains char+attr bytes
                                                        // (optionally terminated by 0xFF data)
                                                        // First, write data[1,3,5,...] Character plane;
                                                        // MAX7456 WriteReg(0x05,0x41)
                                                        //"Character Memory Address High"; 0x02:Attribute bytes;
                                                        // 0x01:character memory address msb
{
   volatile unsigned int Index = 0x0001;                // Index for lookup into data[1..960]                    
   spiWriteReg(DM_ADDRH_WRITE,0x00);                    // initialise the Display Memory high-byte
   spiWriteReg(DM_ADDRL_WRITE,0x00);                    // and the low-byte
   spiWriteReg(DM_MODE_WRITE ,0x41);                    // MAX7456 WriteReg(0x04,0x41) "Display Memory Mode";
                                                        // 0x40:Perform 8-bit operation; 0x01:Auto-Increment
	                                            
   do                                                   // Loop to write the character data
   {
      if (data[Index] == 0xFF) {                        // Check for the break character
           break; }                                     // and finish if found
      spiWriteRegAutoIncr(data[Index]);                 // Write the character
      Index += 2;                                       // Increment the index to the next character, skipping over
                                                        // the attribute.  
   } while(Index < 0x03C1); // 0x03C1 = 961             // And loop back to send the next character
   
   spiWriteRegAutoIncr(0xFF);                           // "Escape Character" to end Auto-Increment mode

   spiWriteReg(DM_ADDRH_WRITE,0x02);                    // Second, write data[2,4,6,...] Attribute plane; MAX7456
                                                        // WriteReg(0x05,0x41) "Character Memory Address High";
                                                        // 0x02:Attribute bytes; 0x01:character memory address msb
   spiWriteReg(DM_ADDRL_WRITE,0x00);
   spiWriteReg(DM_MODE_WRITE ,0x41);                    // MAX7456 WriteReg(0x04,0x41) "Character Memory Mode";
                                                        // 0x40:Perform 8-bit operation; 0x01:Auto-Increment
   Index = 0x0002;
   do
   {
      if (data[Index] == 0xFF)
         break;
      spiWriteRegAutoIncr(data[Index]);
      Index += 2;
   } while(Index < 0x03C1);
   spiWriteRegAutoIncr(0xFF);
}

/**************************************************************************************
 * spiWriteFM
 *
 * Writes to the Character Memory (54 bytes) from "data" extern
**************************************************************************************/
void spiWriteFM()
{
     unsigned char Index;
     
     spiWriteReg(VIDEO_MODE_0_WRITE,spiReadReg
                 (VIDEO_MODE_0_READ)&0xF7);             // Clear bit 0x08 to DISABLE the OSD display
     spiWriteReg(FM_ADDRH_WRITE,data[1]);               // Write the address of the character to be written
                                                  	// MAX7456 glyph tile definition length = 0x36 = 54 bytes
                                                        // MAX7456 64-byte Shadow RAM accessed
                                                        // through FM_DATA_.. FM_ADDR.. contains a single
                                                        // character/glyph-tile shape
     for(Index=0x00; Index<0x36; Index++)
     {
          spiWriteReg(FM_ADDRL_WRITE,Index);            // Write the address within the shadow RAM
          spiWriteReg(FM_DATA_IN_WRITE,data[Index+2]);  // Write the data to the shaddow RAM
     }

     spiWriteReg(FM_MODE_WRITE,0xA0);                   // MAX7456 "Font Memory Mode" write 0xA0 triggers
                                                        // copy from 64-byte Shadow RAM to NV array.
                                                        
     while ((spiReadReg(STATUS_READ) & 0x20) != 0x00);  // Wait while NV Memory status is BUSY
                                                	// MAX7456 0xA0 status bit 0x20: NV Memory Status Busy/~Ready
     
}


// chars 0 - 255 with 54 byte per char
// orginal filename: gluonpilot2.mcm
// Mon, 01 Oct 2012 20:30:52 +0200



//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	------------
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char   chr0[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----##-----
//	 2	----#  #----
//	 3	---#   #----
//	 4	--#    #----
//	 5	--#    #----
//	 6	--###  #----
//	 7	--###  #----
//	 8	----#  #----
//	 9	----#  #----
//	10	----#  #----
//	11	----#  #----
//	12	----#  #----
//	13	---##  ##---
//	14	--#      #--
//	15	--#      #--
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char   chr1[]  = {0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x54,0xa8,0x55,0x52,0xa8,0x55,0x52,0xa8,0x55,0x50,0x28,0x55,0x50,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x54,0x28,0x15,0x52,0xaa,0x85,0x52,0xaa,0x85,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	---######---
//	 2	--#      #--
//	 3	-#        #-
//	 4	#    ###   #
//	 5	#   #####  #
//	 6	#####---#  #
//	 7	-###---#   #
//	 8	------#   ##
//	 9	-----#   ##-
//	10	----#   ##--
//	11	---#   ##---
//	12	--#   ##----
//	13	-#   ######-
//	14	#          #
//	15	#          #
//	16	############
//	17	-##########-
//		000000000011
//		012345678901
const char   chr2[]  = {0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0x80,0xa8,0x2a,0x00,0x28,0x00,0x15,0x28,0x40,0x54,0xa8,0x55,0x52,0xa0,0x55,0x4a,0x81,0x55,0x2a,0x05,0x54,0xa8,0x15,0x52,0xa0,0x55,0x4a,0x80,0x01,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x00,0x00,0x00,0x40,0x00,0x01};


//	 0	------------
//	 1	---######---
//	 2	--#      #--
//	 3	-#        #-
//	 4	#   ####   #
//	 5	#  ######  #
//	 6	####----#  #
//	 7	-##--###   #
//	 8	----#     ##
//	 9	----#     #-
//	10	----####   #
//	11	-##--####  #
//	12	#  #----#  #
//	13	#   ####   #
//	14	##        ##
//	15	-##      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char   chr3[]  = {0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0x00,0xa8,0x28,0x00,0x28,0x00,0x55,0x28,0x41,0x40,0xa8,0x55,0x2a,0xa0,0x55,0x2a,0xa1,0x55,0x00,0xa8,0x41,0x40,0x28,0x28,0x55,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x42,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	-------##---
//	 2	------#  #--
//	 3	-----#   #--
//	 4	----#    #--
//	 5	---#     #--
//	 6	--#   #  #--
//	 7	-#   ##  #--
//	 8	#   ###  #--
//	 9	#  ####  ##-
//	10	#          #
//	11	#          #
//	12	#######  ###
//	13	-######  ##-
//	14	------#  #--
//	15	------#  #--
//	16	------####--
//	17	-------##---
//		000000000011
//		012345678901
const char   chr4[]  = {0x55,0x55,0x55,0x55,0x54,0x15,0x55,0x52,0x85,0x55,0x4a,0x85,0x55,0x2a,0x85,0x54,0xaa,0x85,0x52,0xa2,0x85,0x4a,0x82,0x85,0x2a,0x02,0x85,0x28,0x02,0x81,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x00,0x02,0x80,0x40,0x02,0x81,0x55,0x52,0x85,0x55,0x52,0x85,0x55,0x50,0x05,0x55,0x54,0x15};


//	 0	------------
//	 1	-##########-
//	 2	#          #
//	 3	#          #
//	 4	#  #########
//	 5	#  ########-
//	 6	#        #--
//	 7	#         #-
//	 8	########   #
//	 9	-########  #
//	10	--------#  #
//	11	-##-----#  #
//	12	#  #----#  #
//	13	#   ####   #
//	14	##        ##
//	15	-##      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char   chr5[]  = {0x55,0x55,0x55,0x40,0x00,0x01,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x28,0x00,0x00,0x28,0x00,0x01,0x2a,0xaa,0x85,0x2a,0xaa,0xa1,0x00,0x00,0xa8,0x40,0x00,0x28,0x55,0x55,0x28,0x41,0x55,0x28,0x28,0x55,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x42,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	---######---
//	 2	--#      #--
//	 3	-#        #-
//	 4	#   ####   #
//	 5	#  ######  #
//	 6	#  #----####
//	 7	#  ########-
//	 8	#        #--
//	 9	#         #-
//	10	#  #####   #
//	11	#  ######  #
//	12	#  #----#  #
//	13	#   ####   #
//	14	##        ##
//	15	-##      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char   chr6[]  = {0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x00,0x28,0x00,0x01,0x2a,0xaa,0x85,0x2a,0xaa,0xa1,0x28,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x42,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	-##########-
//	 2	#          #
//	 3	#          #
//	 4	#########  #
//	 5	-#######   #
//	 6	------#   ##
//	 7	-----#   ##-
//	 8	----#   ##--
//	 9	----#  ##---
//	10	----#  #----
//	11	----#  #----
//	12	----#  #----
//	13	----#  #----
//	14	----#  #----
//	15	----#  #----
//	16	----####----
//	17	-----##-----
//		000000000011
//		012345678901
const char   chr7[]  = {0x55,0x55,0x55,0x40,0x00,0x01,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x00,0x00,0x28,0x40,0x00,0xa8,0x55,0x52,0xa0,0x55,0x4a,0x81,0x55,0x2a,0x05,0x55,0x28,0x15,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x00,0x55,0x55,0x41,0x55};


//	 0	------------
//	 1	---######---
//	 2	--#      #--
//	 3	-#        #-
//	 4	#   ####   #
//	 5	#  ######  #
//	 6	#  #----#  #
//	 7	#   ####   #
//	 8	##        ##
//	 9	-#        #-
//	10	#   ####   #
//	11	#  ######  #
//	12	#  #----#  #
//	13	#   ####   #
//	14	##        ##
//	15	-##      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char   chr8[]  = {0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x4a,0xaa,0xa1,0x2a,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x42,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	---######---
//	 2	--#      #--
//	 3	-#        #-
//	 4	#   ####   #
//	 5	#  ######  #
//	 6	#  #----#  #
//	 7	#   #####  #
//	 8	##         #
//	 9	-##        #
//	10	--#######  #
//	11	-########  #
//	12	#  #----#  #
//	13	#   ####   #
//	14	##        ##
//	15	-##      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char   chr9[]  = {0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x28,0x2a,0x00,0x28,0x0a,0xaa,0xa8,0x42,0xaa,0xa8,0x50,0x00,0x28,0x40,0x00,0x28,0x28,0x55,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x42,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	---######---
//	 2	--#      #--
//	 3	-#        #-
//	 4	#   ####   #
//	 5	#  ######  #
//	 6	#  #----#  #
//	 7	#  #----#  #
//	 8	#  #----#  #
//	 9	#  #----#  #
//	10	#  #----#  #
//	11	#  #----#  #
//	12	#  #----#  #
//	13	#   ####   #
//	14	##        ##
//	15	-##      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char  chr10[]  = {0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x42,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	-----##-----
//	 2	----#  #----
//	 3	---#    #---
//	 4	--#      #--
//	 5	-#   ##   #-
//	 6	#   ####   #
//	 7	#  ##--##  #
//	 8	#  #----#  #
//	 9	#  ######  #
//	10	#          #
//	11	#          #
//	12	#  ######  #
//	13	#  ######  #
//	14	#  #----#  #
//	15	#  #----#  #
//	16	####----####
//	17	-##------##-
//		000000000011
//		012345678901
const char  chr11[]  = {0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x54,0xaa,0x15,0x52,0xaa,0x85,0x4a,0x82,0xa1,0x2a,0x00,0xa8,0x28,0x14,0x28,0x28,0x55,0x28,0x28,0x00,0x28,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x28,0x00,0x28,0x28,0x00,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x00,0x55,0x00,0x41,0x55,0x41};


//	 0	------------
//	 1	-########---
//	 2	#        #--
//	 3	#         #-
//	 4	#  #####   #
//	 5	#  ######  #
//	 6	#  #----#  #
//	 7	#  #####   #
//	 8	#         ##
//	 9	#         #-
//	10	#  #####   #
//	11	#  ######  #
//	12	#  #----#  #
//	13	#  #####   #
//	14	#         ##
//	15	#        ##-
//	16	##########--
//	17	-########---
//		000000000011
//		012345678901
const char  chr12[]  = {0x55,0x55,0x55,0x40,0x00,0x15,0x2a,0xaa,0x85,0x2a,0xaa,0xa1,0x28,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x28,0x28,0x00,0xa8,0x2a,0xaa,0xa0,0x2a,0xaa,0xa1,0x28,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x28,0x28,0x00,0xa8,0x2a,0xaa,0xa0,0x2a,0xaa,0x81,0x00,0x00,0x05,0x40,0x00,0x15};


//	 0	------------
//	 1	---######---
//	 2	--#      #--
//	 3	-#        #-
//	 4	#   ####   #
//	 5	#  ######  #
//	 6	#  #----####
//	 7	#  #-----##-
//	 8	#  #--------
//	 9	#  #--------
//	10	#  #--------
//	11	#  #-----##-
//	12	#  #----#  #
//	13	#   ####   #
//	14	##        ##
//	15	-##      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char  chr13[]  = {0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x00,0x28,0x55,0x41,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x41,0x28,0x55,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x42,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	-######-----
//	 2	#      #----
//	 3	#       #---
//	 4	#  ###   #--
//	 5	#  ####   #-
//	 6	#  #--##   #
//	 7	#  #---##  #
//	 8	#  #----#  #
//	 9	#  #----#  #
//	10	#  #----#  #
//	11	#  #---#   #
//	12	#  #--#   ##
//	13	#  ###   ##-
//	14	#       ##--
//	15	#      ##---
//	16	########----
//	17	-######-----
//		000000000011
//		012345678901
const char  chr14[]  = {0x55,0x55,0x55,0x40,0x01,0x55,0x2a,0xa8,0x55,0x2a,0xaa,0x15,0x28,0x0a,0x85,0x28,0x02,0xa1,0x28,0x50,0xa8,0x28,0x54,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x54,0xa8,0x28,0x52,0xa0,0x28,0x0a,0x81,0x2a,0xaa,0x05,0x2a,0xa8,0x15,0x00,0x00,0x55,0x40,0x01,0x55};


//	 0	------------
//	 1	-##########-
//	 2	#          #
//	 3	#          #
//	 4	#  #########
//	 5	#  ########-
//	 6	#  #--------
//	 7	#  ######---
//	 8	#        #--
//	 9	#        #--
//	10	#  #######--
//	11	#  ######---
//	12	#  #--------
//	13	#  ########-
//	14	#          #
//	15	#          #
//	16	############
//	17	-##########-
//		000000000011
//		012345678901
const char  chr15[]  = {0x55,0x55,0x55,0x40,0x00,0x01,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x28,0x00,0x00,0x28,0x00,0x01,0x28,0x55,0x55,0x28,0x00,0x15,0x2a,0xaa,0x85,0x2a,0xaa,0x85,0x28,0x00,0x05,0x28,0x00,0x15,0x28,0x55,0x55,0x28,0x00,0x01,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x00,0x00,0x00,0x40,0x00,0x01};


//	 0	------------
//	 1	-##########-
//	 2	#          #
//	 3	#          #
//	 4	#  #########
//	 5	#  ########-
//	 6	#  #--------
//	 7	#  ######---
//	 8	#        #--
//	 9	#        #--
//	10	#  #######--
//	11	#  ######---
//	12	#  #--------
//	13	#  #--------
//	14	#  #--------
//	15	#  #--------
//	16	####--------
//	17	-##---------
//		000000000011
//		012345678901
const char  chr16[]  = {0x55,0x55,0x55,0x40,0x00,0x01,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x28,0x00,0x00,0x28,0x00,0x01,0x28,0x55,0x55,0x28,0x00,0x15,0x2a,0xaa,0x85,0x2a,0xaa,0x85,0x28,0x00,0x05,0x28,0x00,0x15,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x00,0x55,0x55,0x41,0x55,0x55};


//	 0	------------
//	 1	---######---
//	 2	--#      #--
//	 3	-#        #-
//	 4	#   ###   #-
//	 5	#  #### #  #
//	 6	#  #----#  #
//	 7	#  #----####
//	 8	#  #-######-
//	 9	#  ##      #
//	10	#  ##      #
//	11	#  ######  #
//	12	#  #-####  #
//	13	#   #####  #
//	14	##         #
//	15	-##        #
//	16	--##########
//	17	---########-
//		000000000011
//		012345678901
const char  chr17[]  = {0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0x02,0xa1,0x28,0x02,0x28,0x28,0x55,0x28,0x28,0x55,0x00,0x28,0x40,0x01,0x28,0x2a,0xa8,0x28,0x2a,0xa8,0x28,0x00,0x28,0x28,0x40,0x28,0x2a,0x00,0x28,0x0a,0xaa,0xa8,0x42,0xaa,0xa8,0x50,0x00,0x00,0x54,0x00,0x01};


//	 0	------------
//	 1	-##------##-
//	 2	#  #----#  #
//	 3	#  #----#  #
//	 4	#  #----#  #
//	 5	#  #----#  #
//	 6	#  #----#  #
//	 7	#  ######  #
//	 8	#          #
//	 9	#          #
//	10	#  ######  #
//	11	#  ######  #
//	12	#  #----#  #
//	13	#  #----#  #
//	14	#  #----#  #
//	15	#  #----#  #
//	16	####----####
//	17	-##------##-
//		000000000011
//		012345678901
const char  chr18[]  = {0x55,0x55,0x55,0x41,0x55,0x41,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x00,0x28,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x28,0x00,0x28,0x28,0x00,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x00,0x55,0x00,0x41,0x55,0x41};


//	 0	------------
//	 1	---######---
//	 2	--#      #--
//	 3	--#      #--
//	 4	--###  ###--
//	 5	---##  ##---
//	 6	----#  #----
//	 7	----#  #----
//	 8	----#  #----
//	 9	----#  #----
//	10	----#  #----
//	11	----#  #----
//	12	----#  #----
//	13	---##  ##---
//	14	--#      #--
//	15	--#      #--
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char  chr19[]  = {0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x52,0xaa,0x85,0x50,0x28,0x05,0x54,0x28,0x15,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x54,0x28,0x15,0x52,0xaa,0x85,0x52,0xaa,0x85,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	-----######-
//	 2	----#      #
//	 3	----#      #
//	 4	----###  ###
//	 5	-----##  ##-
//	 6	------#  #--
//	 7	------#  #--
//	 8	------#  #--
//	 9	------#  #--
//	10	------#  #--
//	11	-##---#  #--
//	12	#  #--#  #--
//	13	#   ##   #--
//	14	##      ##--
//	15	-##    ##---
//	16	--######----
//	17	---####-----
//		000000000011
//		012345678901
const char  chr20[]  = {0x55,0x55,0x55,0x55,0x40,0x01,0x55,0x2a,0xa8,0x55,0x2a,0xa8,0x55,0x02,0x80,0x55,0x42,0x81,0x55,0x52,0x85,0x55,0x52,0x85,0x55,0x52,0x85,0x55,0x52,0x85,0x55,0x52,0x85,0x41,0x52,0x85,0x28,0x52,0x85,0x2a,0x0a,0x85,0x0a,0xaa,0x05,0x42,0xa8,0x15,0x50,0x00,0x55,0x54,0x01,0x55};


//	 0	------------
//	 1	-##------##-
//	 2	#  #----#  #
//	 3	#  #---#   #
//	 4	#  #--#   ##
//	 5	#  #-#   ##-
//	 6	#  ##   ##--
//	 7	#  #   ##---
//	 8	#     ##----
//	 9	#     #-----
//	10	#  #   #----
//	11	#  ##   #---
//	12	#  ###   #--
//	13	#  #-##   #-
//	14	#  #--##   #
//	15	#  #---##  #
//	16	####----####
//	17	-##------##-
//		000000000011
//		012345678901
const char  chr21[]  = {0x55,0x55,0x55,0x41,0x55,0x41,0x28,0x55,0x28,0x28,0x54,0xa8,0x28,0x52,0xa0,0x28,0x4a,0x81,0x28,0x2a,0x05,0x28,0xa8,0x15,0x2a,0xa0,0x55,0x2a,0xa1,0x55,0x28,0xa8,0x55,0x28,0x2a,0x15,0x28,0x0a,0x85,0x28,0x42,0xa1,0x28,0x50,0xa8,0x28,0x54,0x28,0x00,0x55,0x00,0x41,0x55,0x41};


//	 0	------------
//	 1	-##---------
//	 2	#  #--------
//	 3	#  #--------
//	 4	#  #--------
//	 5	#  #--------
//	 6	#  #--------
//	 7	#  #--------
//	 8	#  #--------
//	 9	#  #--------
//	10	#  #--------
//	11	#  #--------
//	12	#  #--------
//	13	#  ########-
//	14	#          #
//	15	#          #
//	16	############
//	17	-##########-
//		000000000011
//		012345678901
const char  chr22[]  = {0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x00,0x01,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x00,0x00,0x00,0x40,0x00,0x01};


//	 0	------------
//	 1	-##------##-
//	 2	#  #----#  #
//	 3	#   #--#   #
//	 4	#    ##    #
//	 5	#          #
//	 6	#  #    #  #
//	 7	#  ##  ##  #
//	 8	#  ##  ##  #
//	 9	#  ######  #
//	10	#  #-##-#  #
//	11	#  #----#  #
//	12	#  #----#  #
//	13	#  #----#  #
//	14	#  #----#  #
//	15	#  #----#  #
//	16	####----####
//	17	-##------##-
//		000000000011
//		012345678901
const char  chr23[]  = {0x55,0x55,0x55,0x41,0x55,0x41,0x28,0x55,0x28,0x2a,0x14,0xa8,0x2a,0x82,0xa8,0x2a,0xaa,0xa8,0x28,0xaa,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x00,0x28,0x28,0x41,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x00,0x55,0x00,0x41,0x55,0x41};


//	 0	------------
//	 1	-##------##-
//	 2	#  #----#  #
//	 3	#   #---#  #
//	 4	#    #--#  #
//	 5	#    #--#  #
//	 6	#  #  #-#  #
//	 7	#  #  #-#  #
//	 8	#  ##  ##  #
//	 9	#  ##  ##  #
//	10	#  ###  #  #
//	11	#  #-#  #  #
//	12	#  #-##    #
//	13	#  #--#    #
//	14	#  #--##   #
//	15	#  #---##  #
//	16	####----####
//	17	-##------##-
//		000000000011
//		012345678901
const char  chr24[]  = {0x55,0x55,0x55,0x41,0x55,0x41,0x28,0x55,0x28,0x2a,0x15,0x28,0x2a,0x85,0x28,0x2a,0x85,0x28,0x28,0xa1,0x28,0x28,0xa1,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x0a,0x28,0x28,0x4a,0x28,0x28,0x42,0xa8,0x28,0x52,0xa8,0x28,0x50,0xa8,0x28,0x54,0x28,0x00,0x55,0x00,0x41,0x55,0x41};


//	 0	------------
//	 1	---######---
//	 2	--#      #--
//	 3	-#        #-
//	 4	#   ####   #
//	 5	#  ######  #
//	 6	#  #----#  #
//	 7	#  #----#  #
//	 8	#  #----#  #
//	 9	#  #----#  #
//	10	#  #----#  #
//	11	#  #----#  #
//	12	#  #----#  #
//	13	#   ####   #
//	14	##        ##
//	15	-##      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char  chr25[]  = {0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x42,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	-########---
//	 2	#        #--
//	 3	#         #-
//	 4	#  #####   #
//	 5	#  ######  #
//	 6	#  #----#  #
//	 7	#  #####   #
//	 8	#         ##
//	 9	#        ##-
//	10	#  #######--
//	11	#  ######---
//	12	#  #--------
//	13	#  #--------
//	14	#  #--------
//	15	#  #--------
//	16	####--------
//	17	-##---------
//		000000000011
//		012345678901
const char  chr26[]  = {0x55,0x55,0x55,0x40,0x00,0x15,0x2a,0xaa,0x85,0x2a,0xaa,0xa1,0x28,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x28,0x28,0x00,0xa8,0x2a,0xaa,0xa0,0x2a,0xaa,0x81,0x28,0x00,0x05,0x28,0x00,0x15,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x00,0x55,0x55,0x41,0x55,0x55};


//	 0	------------
//	 1	---######---
//	 2	--#      #--
//	 3	-#        #-
//	 4	#   ####   #
//	 5	#  ######  #
//	 6	#  #----#  #
//	 7	#  #----#  #
//	 8	#  #----#  #
//	 9	#  #-##-#  #
//	10	#  ##  ##  #
//	11	#  ##   #  #
//	12	#  ###     #
//	13	#   ###   ##
//	14	##         #
//	15	-##    ##  #
//	16	--##########
//	17	---####--##-
//		000000000011
//		012345678901
const char  chr27[]  = {0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x41,0x28,0x28,0x28,0x28,0x28,0x2a,0x28,0x28,0x0a,0xa8,0x2a,0x02,0xa0,0x0a,0xaa,0xa8,0x42,0xa8,0x28,0x50,0x00,0x00,0x54,0x01,0x41};


//	 0	------------
//	 1	-########---
//	 2	#        #--
//	 3	#         #-
//	 4	#  #####   #
//	 5	#  ######  #
//	 6	#  #----#  #
//	 7	#  #####   #
//	 8	#         ##
//	 9	#        ##-
//	10	#  #   ###--
//	11	#  ##   #---
//	12	#  ###   #--
//	13	#  #-##   #-
//	14	#  #--##   #
//	15	#  #---##  #
//	16	####----####
//	17	-##------##-
//		000000000011
//		012345678901
const char  chr28[]  = {0x55,0x55,0x55,0x40,0x00,0x15,0x2a,0xaa,0x85,0x2a,0xaa,0xa1,0x28,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x28,0x28,0x00,0xa8,0x2a,0xaa,0xa0,0x2a,0xaa,0x81,0x28,0xa8,0x05,0x28,0x2a,0x15,0x28,0x0a,0x85,0x28,0x42,0xa1,0x28,0x50,0xa8,0x28,0x54,0x28,0x00,0x55,0x00,0x41,0x55,0x41};


//	 0	------------
//	 1	---#######--
//	 2	--#       #-
//	 3	-#         #
//	 4	#   #####  #
//	 5	#  #########
//	 6	#  #-----##-
//	 7	#   #####---
//	 8	##       #--
//	 9	-##       #-
//	10	--######   #
//	11	---######  #
//	12	-##-----#  #
//	13	#  #####   #
//	14	#         ##
//	15	##       ##-
//	16	-#########--
//	17	--#######---
//		000000000011
//		012345678901
const char  chr29[]  = {0x55,0x55,0x55,0x54,0x00,0x05,0x52,0xaa,0xa1,0x4a,0xaa,0xa8,0x2a,0x00,0x28,0x28,0x00,0x00,0x28,0x55,0x41,0x2a,0x00,0x15,0x0a,0xaa,0x85,0x42,0xaa,0xa1,0x50,0x00,0xa8,0x54,0x00,0x28,0x41,0x55,0x28,0x28,0x00,0xa8,0x2a,0xaa,0xa0,0x0a,0xaa,0x81,0x40,0x00,0x05,0x50,0x00,0x15};


//	 0	------------
//	 1	-##########-
//	 2	#          #
//	 3	#          #
//	 4	#####  #####
//	 5	-####  ####-
//	 6	----#  #----
//	 7	----#  #----
//	 8	----#  #----
//	 9	----#  #----
//	10	----#  #----
//	11	----#  #----
//	12	----#  #----
//	13	----#  #----
//	14	----#  #----
//	15	----#  #----
//	16	----####----
//	17	-----##-----
//		000000000011
//		012345678901
const char  chr30[]  = {0x55,0x55,0x55,0x40,0x00,0x01,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x00,0x28,0x00,0x40,0x28,0x01,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x00,0x55,0x55,0x41,0x55};


//	 0	------------
//	 1	-##------##-
//	 2	#  #----#  #
//	 3	#  #----#  #
//	 4	#  #----#  #
//	 5	#  #----#  #
//	 6	#  #----#  #
//	 7	#  #----#  #
//	 8	#  #----#  #
//	 9	#  #----#  #
//	10	#  #----#  #
//	11	#  #----#  #
//	12	#  #----#  #
//	13	#   ####   #
//	14	##        ##
//	15	-##      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char  chr31[]  = {0x55,0x55,0x55,0x41,0x55,0x41,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x42,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	-##------##-
//	 2	#  #----#  #
//	 3	#  #----#  #
//	 4	#  #----#  #
//	 5	#  #----#  #
//	 6	#  #----#  #
//	 7	#  #----#  #
//	 8	#  #----#  #
//	 9	#  #----#  #
//	10	#  #----#  #
//	11	#   #--#   #
//	12	##   ##   ##
//	13	-##      ##-
//	14	--##    ##--
//	15	---##  ##---
//	16	----####----
//	17	-----##-----
//		000000000011
//		012345678901
const char  chr32[]  = {0x55,0x55,0x55,0x41,0x55,0x41,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x2a,0x14,0xa8,0x0a,0x82,0xa0,0x42,0xaa,0x81,0x50,0xaa,0x05,0x54,0x28,0x15,0x55,0x00,0x55,0x55,0x41,0x55};


//	 0	------------
//	 1	-##------##-
//	 2	#  #----#  #
//	 3	#  #----#  #
//	 4	#  #----#  #
//	 5	#  #----#  #
//	 6	#  #----#  #
//	 7	#  #-##-#  #
//	 8	#  ##  ##  #
//	 9	#  ##  ##  #
//	10	#  ##  ##  #
//	11	#  ##  ##  #
//	12	#  ##  ##  #
//	13	#          #
//	14	##        ##
//	15	-##  ##  ##-
//	16	--########--
//	17	---##--##---
//		000000000011
//		012345678901
const char  chr33[]  = {0x55,0x55,0x55,0x41,0x55,0x41,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x41,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x2a,0xaa,0xa8,0x0a,0xaa,0xa0,0x42,0x82,0x81,0x50,0x00,0x05,0x54,0x14,0x15};


//	 0	------------
//	 1	-##------##-
//	 2	#  #----#  #
//	 3	#  #----#  #
//	 4	#  #----#  #
//	 5	#   #--#   #
//	 6	##   ##   ##
//	 7	-##      ##-
//	 8	--##    ##--
//	 9	---#    #---
//	10	--#      #--
//	11	-#   ##   #-
//	12	#   ####   #
//	13	#  ##--##  #
//	14	#  #----#  #
//	15	#  #----#  #
//	16	####----####
//	17	-##------##-
//		000000000011
//		012345678901
const char  chr34[]  = {0x55,0x55,0x55,0x41,0x55,0x41,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x2a,0x14,0xa8,0x0a,0x82,0xa0,0x42,0xaa,0x81,0x50,0xaa,0x05,0x54,0xaa,0x15,0x52,0xaa,0x85,0x4a,0x82,0xa1,0x2a,0x00,0xa8,0x28,0x14,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x00,0x55,0x00,0x41,0x55,0x41};


//	 0	------------
//	 1	-##------##-
//	 2	#  #----#  #
//	 3	#  #----#  #
//	 4	#  #----#  #
//	 5	#  #----#  #
//	 6	#  #----#  #
//	 7	#   #--#   #
//	 8	##   ##   ##
//	 9	-##      ##-
//	10	--##    ##--
//	11	---##  ##---
//	12	----#  #----
//	13	----#  #----
//	14	----#  #----
//	15	----#  #----
//	16	----####----
//	17	-----##-----
//		000000000011
//		012345678901
const char  chr35[]  = {0x55,0x55,0x55,0x41,0x55,0x41,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x2a,0x14,0xa8,0x0a,0x82,0xa0,0x42,0xaa,0x81,0x50,0xaa,0x05,0x54,0x28,0x15,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x00,0x55,0x55,0x41,0x55};


//	 0	------------
//	 1	-##########-
//	 2	#          #
//	 3	#          #
//	 4	#########  #
//	 5	-#######   #
//	 6	------#   ##
//	 7	-----#   ##-
//	 8	----#   ##--
//	 9	---#   ##---
//	10	--#   ##----
//	11	-#   ##-----
//	12	#   ##------
//	13	#  ########-
//	14	#          #
//	15	#          #
//	16	############
//	17	-##########-
//		000000000011
//		012345678901
const char  chr36[]  = {0x55,0x55,0x55,0x40,0x00,0x01,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x00,0x00,0x28,0x40,0x00,0xa8,0x55,0x52,0xa0,0x55,0x4a,0x81,0x55,0x2a,0x05,0x54,0xa8,0x15,0x52,0xa0,0x55,0x4a,0x81,0x55,0x2a,0x05,0x55,0x28,0x00,0x01,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x00,0x00,0x00,0x40,0x00,0x01};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	---######---
//	 4	--#      #--
//	 5	--#       #-
//	 6	--######   #
//	 7	---######  #
//	 8	--#     #  #
//	 9	-#         #
//	10	#   ####   #
//	11	#  ######  #
//	12	#  #----#  #
//	13	#   ####   #
//	14	##         #
//	15	-##     #  #
//	16	--##########
//	17	---#####-##-
//		000000000011
//		012345678901
const char  chr37[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x52,0xaa,0xa1,0x50,0x00,0xa8,0x54,0x00,0x28,0x52,0xaa,0x28,0x4a,0xaa,0xa8,0x2a,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa8,0x42,0xaa,0x28,0x50,0x00,0x00,0x54,0x00,0x41};


//	 0	------------
//	 1	-##---------
//	 2	#  #--------
//	 3	#  #--------
//	 4	#  #-###----
//	 5	#  ##   #---
//	 6	#  #     #--
//	 7	#     #   #-
//	 8	#    ###   #
//	 9	#   ##-##  #
//	10	#   #---#  #
//	11	#   #---#  #
//	12	#    #-#   #
//	13	#     #   ##
//	14	#  #     ##-
//	15	#  ##   ##--
//	16	#########---
//	17	-##--###----
//		000000000011
//		012345678901
const char  chr38[]  = {0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x40,0x55,0x28,0x2a,0x15,0x28,0xaa,0x85,0x2a,0xa2,0xa1,0x2a,0x80,0xa8,0x2a,0x04,0x28,0x2a,0x15,0x28,0x2a,0x15,0x28,0x2a,0x84,0xa8,0x2a,0xa2,0xa0,0x28,0xaa,0x81,0x28,0x2a,0x05,0x00,0x00,0x15,0x41,0x40,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	---######---
//	 5	--#      #--
//	 6	-#        #-
//	 7	#   ####   #
//	 8	#  ######  #
//	 9	#  #----#  #
//	10	#  #----####
//	11	#  #-----##-
//	12	#  #----#  #
//	13	#   ####   #
//	14	##        ##
//	15	-##      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char  chr39[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x28,0x28,0x55,0x00,0x28,0x55,0x41,0x28,0x55,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x42,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	---------##-
//	 2	--------#  #
//	 3	--------#  #
//	 4	----###-#  #
//	 5	---#   ##  #
//	 6	--#     #  #
//	 7	-#   #     #
//	 8	#   ###    #
//	 9	#  ##-##   #
//	10	#  #---#   #
//	11	#  #---#   #
//	12	#   #-#    #
//	13	##   #     #
//	14	-##     #  #
//	15	--##   ##  #
//	16	---#########
//	17	----###--##-
//		000000000011
//		012345678901
const char  chr40[]  = {0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x01,0x28,0x54,0xa8,0x28,0x52,0xaa,0x28,0x4a,0x8a,0xa8,0x2a,0x02,0xa8,0x28,0x10,0xa8,0x28,0x54,0xa8,0x28,0x54,0xa8,0x2a,0x12,0xa8,0x0a,0x8a,0xa8,0x42,0xaa,0x28,0x50,0xa8,0x28,0x54,0x00,0x00,0x55,0x01,0x41};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	---######---
//	 5	--#      #--
//	 6	-#        #-
//	 7	#   ####   #
//	 8	#  ######  #
//	 9	#          #
//	10	#         ##
//	11	#  ########-
//	12	#  ########-
//	13	#   ####   #
//	14	##        ##
//	15	-##      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char  chr41[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0x00,0xa8,0x28,0x00,0x28,0x2a,0xaa,0xa8,0x2a,0xaa,0xa0,0x28,0x00,0x01,0x28,0x00,0x01,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x42,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	------####--
//	 2	-----#    #-
//	 3	----#     #-
//	 4	----#  ####-
//	 5	--###  ###--
//	 6	-#        #-
//	 7	-#        #-
//	 8	-####  ####-
//	 9	--###  ###--
//	10	----#  #----
//	11	----#  #----
//	12	----#  #----
//	13	----#  #----
//	14	----#  #----
//	15	----#  #----
//	16	----####----
//	17	-----##-----
//		000000000011
//		012345678901
const char  chr42[]  = {0x55,0x55,0x55,0x55,0x50,0x05,0x55,0x4a,0xa1,0x55,0x2a,0xa1,0x55,0x28,0x01,0x50,0x28,0x05,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x40,0x28,0x01,0x50,0x28,0x05,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x00,0x55,0x55,0x41,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	---######---
//	 4	--#      #--
//	 5	-#        #-
//	 6	#   ####   #
//	 7	#  ######  #
//	 8	#   ####   #
//	 9	##         #
//	10	-##     #  #
//	11	--#######  #
//	12	--#######  #
//	13	-#  ####   #
//	14	-#        ##
//	15	-##      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char  chr43[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0x00,0xa8,0x28,0x00,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa8,0x42,0xaa,0x28,0x50,0x00,0x28,0x50,0x00,0x28,0x4a,0x00,0xa8,0x4a,0xaa,0xa0,0x42,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	-##---------
//	 2	#  #--------
//	 3	#  #--------
//	 4	#  #-###----
//	 5	#  ##   #---
//	 6	#  #     #--
//	 7	#     #   #-
//	 8	#    ###   #
//	 9	#   ##-##  #
//	10	#  ##---#  #
//	11	#  #----#  #
//	12	#  #----#  #
//	13	#  #----#  #
//	14	#  #----#  #
//	15	#  #----#  #
//	16	####----####
//	17	-##------##-
//		000000000011
//		012345678901
const char  chr44[]  = {0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x40,0x55,0x28,0x2a,0x15,0x28,0xaa,0x85,0x2a,0xa2,0xa1,0x2a,0x80,0xa8,0x2a,0x04,0x28,0x28,0x15,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x00,0x55,0x00,0x41,0x55,0x41};


//	 0	------------
//	 1	------------
//	 2	-----##-----
//	 3	----#  #----
//	 4	----#  #----
//	 5	----####----
//	 6	---####-----
//	 7	--#    #----
//	 8	--#    #----
//	 9	--###  #----
//	10	---##  #----
//	11	----#  #----
//	12	----#  #----
//	13	----#   #---
//	14	----##   #--
//	15	-----##  #--
//	16	------####--
//	17	-------##---
//		000000000011
//		012345678901
const char  chr45[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x00,0x55,0x54,0x01,0x55,0x52,0xa8,0x55,0x52,0xa8,0x55,0x50,0x28,0x55,0x54,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x2a,0x15,0x55,0x0a,0x85,0x55,0x42,0x85,0x55,0x50,0x05,0x55,0x54,0x15};


//	 0	-------##---
//	 1	------#  #--
//	 2	------#  #--
//	 3	------####--
//	 4	-----####---
//	 5	----#    #--
//	 6	----#    #--
//	 7	----###  #--
//	 8	-----##  #--
//	 9	------#  #--
//	10	------#  #--
//	11	------#  #--
//	12	------#  #--
//	13	---###   #--
//	14	--#     ##--
//	15	--#    ##---
//	16	--######----
//	17	---####-----
//		000000000011
//		012345678901
const char  chr46[]  = {0x55,0x54,0x15,0x55,0x52,0x85,0x55,0x52,0x85,0x55,0x50,0x05,0x55,0x40,0x15,0x55,0x2a,0x85,0x55,0x2a,0x85,0x55,0x02,0x85,0x55,0x42,0x85,0x55,0x52,0x85,0x55,0x52,0x85,0x55,0x52,0x85,0x55,0x52,0x85,0x54,0x0a,0x85,0x52,0xaa,0x05,0x52,0xa8,0x15,0x50,0x00,0x55,0x54,0x01,0x55};


//	 0	------------
//	 1	-##---------
//	 2	#  #--------
//	 3	#  #--------
//	 4	#  #-----##-
//	 5	#  #----#  #
//	 6	#  #---#   #
//	 7	#  #--#   ##
//	 8	#  #-#   ##-
//	 9	#  ##   ##--
//	10	#  #   ##---
//	11	#       #---
//	12	#    #   #--
//	13	#   ###   #-
//	14	#  ##-##   #
//	15	#  #---##  #
//	16	####----####
//	17	-##------##-
//		000000000011
//		012345678901
const char  chr47[]  = {0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x41,0x28,0x55,0x28,0x28,0x54,0xa8,0x28,0x52,0xa0,0x28,0x4a,0x81,0x28,0x2a,0x05,0x28,0xa8,0x15,0x2a,0xaa,0x15,0x2a,0x8a,0x85,0x2a,0x02,0xa1,0x28,0x10,0xa8,0x28,0x54,0x28,0x00,0x55,0x00,0x41,0x55,0x41};


//	 0	------------
//	 1	-----##-----
//	 2	----#  #----
//	 3	----#  #----
//	 4	----#  #----
//	 5	----#  #----
//	 6	----#  #----
//	 7	----#  #----
//	 8	----#  #----
//	 9	----#  #----
//	10	----#  #----
//	11	----#  #----
//	12	----#  #----
//	13	----#  #----
//	14	----#  #----
//	15	----#  #----
//	16	----####----
//	17	-----##-----
//		000000000011
//		012345678901
const char  chr48[]  = {0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x00,0x55,0x55,0x41,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	-##-#####---
//	 5	#  #     #--
//	 6	#         #-
//	 7	#   #  #   #
//	 8	#  ##  ##  #
//	 9	#  ##  ##  #
//	10	#  ##  ##  #
//	11	#  ##  ##  #
//	12	#  ##  ##  #
//	13	#  ##  ##  #
//	14	#  ##  ##  #
//	15	#  ##  ##  #
//	16	############
//	17	-##--##--##-
//		000000000011
//		012345678901
const char  chr49[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x00,0x15,0x28,0xaa,0x85,0x2a,0xaa,0xa1,0x2a,0x28,0xa8,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x00,0x00,0x00,0x41,0x41,0x41};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	-##-#####---
//	 5	#  #     #--
//	 6	#         #-
//	 7	#   ####   #
//	 8	#  ######  #
//	 9	#  #----#  #
//	10	#  #----#  #
//	11	#  #----#  #
//	12	#  #----#  #
//	13	#  #----#  #
//	14	#  #----#  #
//	15	#  #----#  #
//	16	####----####
//	17	-##------##-
//		000000000011
//		012345678901
const char  chr50[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x00,0x15,0x28,0xaa,0x85,0x2a,0xaa,0xa1,0x2a,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x00,0x55,0x00,0x41,0x55,0x41};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	---######---
//	 5	--#      #--
//	 6	-#        #-
//	 7	#   ####   #
//	 8	#  ######  #
//	 9	#  #----#  #
//	10	#  #----#  #
//	11	#  #----#  #
//	12	#  #----#  #
//	13	#   ####   #
//	14	##        ##
//	15	-##      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char  chr51[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x42,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	-##-#####---
//	 4	#  #     #--
//	 5	#         #-
//	 6	#    ###   #
//	 7	#   #####  #
//	 8	#   #---#  #
//	 9	#   #---#  #
//	10	#    ###   #
//	11	#         ##
//	12	#  #     ##-
//	13	#  #######--
//	14	#  ######---
//	15	#  #--------
//	16	####--------
//	17	-##---------
//		000000000011
//		012345678901
const char  chr52[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x00,0x15,0x28,0xaa,0x85,0x2a,0xaa,0xa1,0x2a,0x80,0xa8,0x2a,0x00,0x28,0x2a,0x15,0x28,0x2a,0x15,0x28,0x2a,0x80,0xa8,0x2a,0xaa,0xa0,0x28,0xaa,0x81,0x28,0x00,0x05,0x28,0x00,0x15,0x28,0x55,0x55,0x00,0x55,0x55,0x41,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	---#####-##-
//	 4	--#     #  #
//	 5	-#         #
//	 6	#   ###    #
//	 7	#  #####   #
//	 8	#  #---#   #
//	 9	#  #---#   #
//	10	#   ###    #
//	11	##         #
//	12	-##    #   #
//	13	--#######  #
//	14	---####-#  #
//	15	--------#  #
//	16	--------####
//	17	---------##-
//		000000000011
//		012345678901
const char  chr53[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x54,0x00,0x41,0x52,0xaa,0x28,0x4a,0xaa,0xa8,0x2a,0x02,0xa8,0x28,0x00,0xa8,0x28,0x54,0xa8,0x28,0x54,0xa8,0x2a,0x02,0xa8,0x0a,0xaa,0xa8,0x42,0xa8,0xa8,0x50,0x00,0x28,0x54,0x01,0x28,0x55,0x55,0x28,0x55,0x55,0x00,0x55,0x55,0x41};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	-##--####---
//	 5	#  ##    #--
//	 6	#  #      #-
//	 7	#     ##   #
//	 8	#    ####  #
//	 9	#   ##--####
//	10	#  ##----##-
//	11	#  #--------
//	12	#  #--------
//	13	#  #--------
//	14	#  #--------
//	15	#  #--------
//	16	####--------
//	17	-##---------
//		000000000011
//		012345678901
const char  chr54[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x40,0x15,0x28,0x2a,0x85,0x28,0xaa,0xa1,0x2a,0xa0,0xa8,0x2a,0x80,0x28,0x2a,0x05,0x00,0x28,0x15,0x41,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x00,0x55,0x55,0x41,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	---######---
//	 5	--#      #--
//	 6	-#        #-
//	 7	#   ####   #
//	 8	#   #####  #
//	 9	##     #####
//	10	-###     ##-
//	11	-#####    #-
//	12	#  #####   #
//	13	#   ####   #
//	14	##        ##
//	15	-##      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char  chr55[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0x00,0xa8,0x2a,0x00,0x28,0x0a,0xa8,0x00,0x40,0xaa,0x81,0x40,0x0a,0xa1,0x28,0x00,0xa8,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x42,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	-----##-----
//	 2	----#  #----
//	 3	----#  #----
//	 4	---##  ##---
//	 5	--#      #--
//	 6	--#      #--
//	 7	--###  ###--
//	 8	---##  ##---
//	 9	----#  #----
//	10	----#  #----
//	11	----#  #----
//	12	----#  #----
//	13	----#   #---
//	14	----##   #--
//	15	-----##  #--
//	16	------####--
//	17	-------##---
//		000000000011
//		012345678901
const char  chr56[]  = {0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x54,0x28,0x15,0x52,0xaa,0x85,0x52,0xaa,0x85,0x50,0x28,0x05,0x54,0x28,0x15,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x2a,0x15,0x55,0x0a,0x85,0x55,0x42,0x85,0x55,0x50,0x05,0x55,0x54,0x15};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	-##------##-
//	 5	#  #----#  #
//	 6	#  #----#  #
//	 7	#  #----#  #
//	 8	#  #----#  #
//	 9	#  #----#  #
//	10	#  #----#  #
//	11	#  #----#  #
//	12	#  #----#  #
//	13	#   ####   #
//	14	##        ##
//	15	-##      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char  chr57[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x41,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x42,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	-##------##-
//	 5	#  #----#  #
//	 6	#  #----#  #
//	 7	#  #----#  #
//	 8	#  #----#  #
//	 9	#  #----#  #
//	10	#  #----#  #
//	11	#   #--#   #
//	12	##   ##   ##
//	13	-##      ##-
//	14	--##    ##--
//	15	---##  ##---
//	16	----####----
//	17	-----##-----
//		000000000011
//		012345678901
const char  chr58[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x41,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x2a,0x14,0xa8,0x0a,0x82,0xa0,0x42,0xaa,0x81,0x50,0xaa,0x05,0x54,0x28,0x15,0x55,0x00,0x55,0x55,0x41,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	-##------##-
//	 5	#  #----#  #
//	 6	#  #----#  #
//	 7	#  #----#  #
//	 8	#  #-##-#  #
//	 9	#  ##  ##  #
//	10	#  ##  ##  #
//	11	#  ##  ##  #
//	12	#  ##  ##  #
//	13	#   #  #   #
//	14	##        ##
//	15	-##  ##  ##-
//	16	--########--
//	17	---##--##---
//		000000000011
//		012345678901
const char  chr59[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x41,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x41,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x2a,0x28,0xa8,0x0a,0xaa,0xa0,0x42,0x82,0x81,0x50,0x00,0x05,0x54,0x14,0x15};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	-##------##-
//	 5	#  #----#  #
//	 6	#   #--#   #
//	 7	##   ##   ##
//	 8	-##      ##-
//	 9	--##    ##--
//	10	---##  ##---
//	11	---#    #---
//	12	--#      #--
//	13	-#   ##   #-
//	14	#   ####   #
//	15	#  ##--##  #
//	16	####----####
//	17	-##------##-
//		000000000011
//		012345678901
const char  chr60[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x41,0x28,0x55,0x28,0x2a,0x14,0xa8,0x0a,0x82,0xa0,0x42,0xaa,0x81,0x50,0xaa,0x05,0x54,0x28,0x15,0x54,0xaa,0x15,0x52,0xaa,0x85,0x4a,0x82,0xa1,0x2a,0x00,0xa8,0x28,0x14,0x28,0x00,0x55,0x00,0x41,0x55,0x41};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	-##------##-
//	 4	#  #----#  #
//	 5	#  #----#  #
//	 6	#  #---#   #
//	 7	#  #---#   #
//	 8	#  #--#    #
//	 9	#   ##     #
//	10	##      #  #
//	11	-##    ##  #
//	12	--#######  #
//	13	---#####   #
//	14	--#       ##
//	15	--#      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char  chr61[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x41,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x54,0xa8,0x28,0x54,0xa8,0x28,0x52,0xa8,0x2a,0x0a,0xa8,0x0a,0xaa,0x28,0x42,0xa8,0x28,0x50,0x00,0x28,0x54,0x00,0xa8,0x52,0xaa,0xa0,0x52,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	-##########-
//	 5	#          #
//	 6	#          #
//	 7	########   #
//	 8	-######   ##
//	 9	-----#   ##-
//	10	----#   ##--
//	11	---#   ##---
//	12	--#   ##----
//	13	-#   ######-
//	14	#          #
//	15	#          #
//	16	############
//	17	-##########-
//		000000000011
//		012345678901
const char  chr62[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x40,0x00,0x01,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x00,0x00,0xa8,0x40,0x02,0xa0,0x55,0x4a,0x81,0x55,0x2a,0x05,0x54,0xa8,0x15,0x52,0xa0,0x55,0x4a,0x80,0x01,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x00,0x00,0x00,0x40,0x00,0x01};


//	 0	------------
//	 1	------------
//	 2	--------##--
//	 3	-------#  #-
//	 4	------#  ##-
//	 5	-----#  ##--
//	 6	----#  ##---
//	 7	----#  #----
//	 8	----#  #----
//	 9	----#  #----
//	10	----#  #----
//	11	----#  #----
//	12	----#  #----
//	13	----##  #---
//	14	-----##  #--
//	15	------##  #-
//	16	-------####-
//	17	--------##--
//		000000000011
//		012345678901
const char  chr63[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x05,0x55,0x54,0xa1,0x55,0x52,0x81,0x55,0x4a,0x05,0x55,0x28,0x15,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x0a,0x15,0x55,0x42,0x85,0x55,0x50,0xa1,0x55,0x54,0x01,0x55,0x55,0x05};


//	 0	------------
//	 1	------------
//	 2	---##-------
//	 3	--#  #------
//	 4	--##  #-----
//	 5	---##  #----
//	 6	----##  #---
//	 7	-----#  #---
//	 8	-----#  #---
//	 9	-----#  #---
//	10	-----#  #---
//	11	-----#  #---
//	12	-----#  #---
//	13	----#  ##---
//	14	---#  ##----
//	15	--#  ##-----
//	16	--####------
//	17	---##-------
//		000000000011
//		012345678901
const char  chr64[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x54,0x15,0x55,0x52,0x85,0x55,0x50,0xa1,0x55,0x54,0x28,0x55,0x55,0x0a,0x15,0x55,0x4a,0x15,0x55,0x4a,0x15,0x55,0x4a,0x15,0x55,0x4a,0x15,0x55,0x4a,0x15,0x55,0x4a,0x15,0x55,0x28,0x15,0x54,0xa0,0x55,0x52,0x81,0x55,0x50,0x05,0x55,0x54,0x15,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	------------
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	-------##---
//	14	------#  #--
//	15	------#  #--
//	16	------####--
//	17	-------##---
//		000000000011
//		012345678901
const char  chr65[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x54,0x15,0x55,0x52,0x85,0x55,0x52,0x85,0x55,0x50,0x05,0x55,0x54,0x15};


//	 0	------------
//	 1	---######---
//	 2	--#      #--
//	 3	-#        #-
//	 4	#   ####   #
//	 5	#  ######  #
//	 6	####----#  #
//	 7	-##----#   #
//	 8	------#   ##
//	 9	-----#   ##-
//	10	----#   ##--
//	11	----#  ##---
//	12	----####----
//	13	-----##-----
//	14	----#  #----
//	15	----#  #----
//	16	----####----
//	17	-----##-----
//		000000000011
//		012345678901
const char  chr66[]  = {0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0x00,0xa8,0x28,0x00,0x28,0x00,0x55,0x28,0x41,0x54,0xa8,0x55,0x52,0xa0,0x55,0x4a,0x81,0x55,0x2a,0x05,0x55,0x28,0x15,0x55,0x00,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x00,0x55,0x55,0x41,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	-----##-----
//	 4	----#  #----
//	 5	----#  #----
//	 6	----####----
//	 7	-----##-----
//	 8	------------
//	 9	-----##-----
//	10	----#  #----
//	11	----#  #----
//	12	---#  ##----
//	13	--#  ##-----
//	14	--####------
//	15	---##-------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char  chr67[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x00,0x55,0x55,0x41,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x54,0xa0,0x55,0x52,0x81,0x55,0x50,0x05,0x55,0x54,0x15,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	-----##-----
//	 4	----#  #----
//	 5	----#  #----
//	 6	----####----
//	 7	-----##-----
//	 8	------------
//	 9	------------
//	10	------------
//	11	-----##-----
//	12	----#  #----
//	13	----#  #----
//	14	----####----
//	15	-----##-----
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char  chr68[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x00,0x55,0x55,0x41,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x00,0x55,0x55,0x41,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	------------
//	 8	------------
//	 9	------------
//	10	------------
//	11	-----##-----
//	12	----#  #----
//	13	----#  #----
//	14	---#  ##----
//	15	--#  ##-----
//	16	--####------
//	17	---##-------
//		000000000011
//		012345678901
const char  chr69[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x54,0xa0,0x55,0x52,0x81,0x55,0x50,0x05,0x55,0x54,0x15,0x55};


//	 0	------#-----
//	 1	-----# #----
//	 2	----#   #---
//	 3	----##  #---
//	 4	-----## #---
//	 5	------# #---
//	 6	-----# ##---
//	 7	-----###----
//	 8	------#-----
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char  chr70[]  = {0x55,0x51,0x55,0x55,0x48,0x55,0x55,0x2a,0x15,0x55,0x0a,0x15,0x55,0x42,0x15,0x55,0x52,0x15,0x55,0x48,0x15,0x55,0x40,0x55,0x55,0x51,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	---------##-
//	 4	--------#  #
//	 5	-------#   #
//	 6	------#   ##
//	 7	-----#   ##-
//	 8	----#   ##--
//	 9	---#   ##---
//	10	--#   ##----
//	11	-#   ##-----
//	12	#   ##------
//	13	#  ##-------
//	14	####--------
//	15	-##---------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char  chr71[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x54,0xa8,0x55,0x52,0xa0,0x55,0x4a,0x81,0x55,0x2a,0x05,0x54,0xa8,0x15,0x52,0xa0,0x55,0x4a,0x81,0x55,0x2a,0x05,0x55,0x28,0x15,0x55,0x00,0x55,0x55,0x41,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	---#----#---
//	 1	--# #--# #--
//	 2	-#   ##   #-
//	 3	-##  ###  #-
//	 4	--## #-## #-
//	 5	---# #--# #-
//	 6	--# ##-# ##-
//	 7	--###--###--
//	 8	---#----#---
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char  chr72[]  = {0x54,0x55,0x15,0x52,0x14,0x85,0x4a,0x82,0xa1,0x42,0x80,0xa1,0x50,0x84,0x21,0x54,0x85,0x21,0x52,0x04,0x81,0x50,0x14,0x05,0x54,0x55,0x15,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	----######--
//	 7	---#      #-
//	 8	---#      #-
//	 9	---########-
//	10	----######--
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char  chr73[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x05,0x54,0xaa,0xa1,0x54,0xaa,0xa1,0x54,0x00,0x01,0x55,0x00,0x05,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	--------##--
//	 2	-------#  #-
//	 3	------#   #-
//	 4	-----#   ##-
//	 5	----#   ##--
//	 6	---#   ##---
//	 7	--#   ##----
//	 8	-#   ##-----
//	 9	-#   #------
//	10	-##   #-----
//	11	--##   #----
//	12	---##   #---
//	13	----##   #--
//	14	-----##   #-
//	15	------##  #-
//	16	-------####-
//	17	--------##--
//		000000000011
//		012345678901
const char  chr74[]  = {0x55,0x55,0x55,0x55,0x55,0x05,0x55,0x54,0xa1,0x55,0x52,0xa1,0x55,0x4a,0x81,0x55,0x2a,0x05,0x54,0xa8,0x15,0x52,0xa0,0x55,0x4a,0x81,0x55,0x4a,0x85,0x55,0x42,0xa1,0x55,0x50,0xa8,0x55,0x54,0x2a,0x15,0x55,0x0a,0x85,0x55,0x42,0xa1,0x55,0x50,0xa1,0x55,0x54,0x01,0x55,0x55,0x05};


//	 0	------------
//	 1	--##--------
//	 2	-#  #-------
//	 3	-#   #------
//	 4	-##   #-----
//	 5	--##   #----
//	 6	---##   #---
//	 7	----##   #--
//	 8	-----##   #-
//	 9	------#   #-
//	10	-----#   ##-
//	11	----#   ##--
//	12	---#   ##---
//	13	--#   ##----
//	14	-#   ##-----
//	15	-#  ##------
//	16	-####-------
//	17	--##--------
//		000000000011
//		012345678901
const char  chr75[]  = {0x55,0x55,0x55,0x50,0x55,0x55,0x4a,0x15,0x55,0x4a,0x85,0x55,0x42,0xa1,0x55,0x50,0xa8,0x55,0x54,0x2a,0x15,0x55,0x0a,0x85,0x55,0x42,0xa1,0x55,0x52,0xa1,0x55,0x4a,0x81,0x55,0x2a,0x05,0x54,0xa8,0x15,0x52,0xa0,0x55,0x4a,0x81,0x55,0x4a,0x05,0x55,0x40,0x15,0x55,0x50,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	----####----
//	 4	---#    #---
//	 5	--# #### #--
//	 6	-# ###### #-
//	 7	# ##  # ## #
//	 8	# # ##  ## #
//	 9	# # ### ## #
//	10	# # ##  ## #
//	11	# ##  # # ##
//	12	# ###### ##-
//	13	## ###-###--
//	14	-## ##### #-
//	15	--##     ##-
//	16	---#######--
//	17	----#####---
//		000000000011
//		012345678901
const char  chr76[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x55,0x54,0xaa,0x15,0x52,0x00,0x85,0x48,0x00,0x21,0x20,0xa2,0x08,0x22,0x0a,0x08,0x22,0x02,0x08,0x22,0x0a,0x08,0x20,0xa2,0x20,0x20,0x00,0x81,0x08,0x04,0x05,0x42,0x00,0x21,0x50,0xaa,0x81,0x54,0x00,0x05,0x55,0x00,0x15};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	------------
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	-----##-----
//	13	----#  #----
//	14	----#  #----
//	15	-----##-----
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char  chr77[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x41,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	-----##-----
//	 8	----#  #----
//	 9	----#  #----
//	10	-----##-----
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char  chr78[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x41,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	-----##-----
//	 3	----#  #----
//	 4	----#  #----
//	 5	-----##-----
//	 6	------------
//	 7	------------
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char  chr79[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x41,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	------------
//	 8	------------
//	 9	------------
//	10	-----##-----
//	11	----#  #----
//	12	----#  #----
//	13	-----##-----
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char  chr80[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x55,0x28,0x55,0x55,0x41,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	-##------##-
//	 1	#  ######  #
//	 2	#  #    #  #
//	 3	####    ####
//	 4	### #### ###
//	 5	#  ######  #
//	 6	#  #----#  #
//	 7	#  #----#  #
//	 8	#  #----#  #
//	 9	#  #----#  #
//	10	#  #----#  #
//	11	#  #----#  #
//	12	#  #----#  #
//	13	#   ####   #
//	14	##        ##
//	15	-##      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char  chr81[]  = {0x41,0x55,0x41,0x28,0x00,0x28,0x28,0xaa,0x28,0x00,0xaa,0x00,0x02,0x00,0x80,0x28,0x00,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x42,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	-##------##-
//	 1	#  #----#  #
//	 2	#  #----#  #
//	 3	####----####
//	 4	####----####
//	 5	#  #----#  #
//	 6	#  #----#  #
//	 7	#  #----#  #
//	 8	#  #----#  #
//	 9	#  #----#  #
//	10	#  #----#  #
//	11	#  #----#  #
//	12	#  #----#  #
//	13	#   ####   #
//	14	##        ##
//	15	-##      ##-
//	16	--########--
//	17	---######---
//		000000000011
//		012345678901
const char  chr82[]  = {0x41,0x55,0x41,0x28,0x55,0x28,0x28,0x55,0x28,0x00,0x55,0x00,0x00,0x55,0x00,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x28,0x55,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x42,0xaa,0x81,0x50,0x00,0x05,0x54,0x00,0x15};


//	 0	------------
//	 1	--#######---
//	 2	-#       #--
//	 3	#         #-
//	 4	#  #####   #
//	 5	#  ######  #
//	 6	#  #####   #
//	 7	#  ##     ##
//	 8	#  ##     #-
//	 9	#  #####   #
//	10	#  ######  #
//	11	#  #####   #
//	12	#  ##     ##
//	13	#  ##    ##-
//	14	#  #######--
//	15	#  ######---
//	16	#  ##-------
//	17	#####-------
//		000000000011
//		012345678901
const char  chr83[]  = {0x55,0x55,0x55,0x50,0x00,0x15,0x4a,0xaa,0x85,0x2a,0xaa,0xa1,0x28,0x00,0xa8,0x28,0x00,0x28,0x28,0x00,0xa8,0x28,0x2a,0xa0,0x28,0x2a,0xa1,0x28,0x00,0xa8,0x28,0x00,0x28,0x28,0x00,0xa8,0x28,0x2a,0xa0,0x28,0x2a,0x81,0x28,0x00,0x05,0x28,0x00,0x15,0x28,0x15,0x55,0x00,0x15,0x55};


//	 0	---#    #---
//	 1	--#  ##  #--
//	 2	--#  ##  #--
//	 3	---##  ##---
//	 4	---#    #---
//	 5	--#      #--
//	 6	-#   ##   #-
//	 7	#   ####   #
//	 8	#  ##--##  #
//	 9	#  #----#  #
//	10	#  ######  #
//	11	#          #
//	12	#          #
//	13	#  ######  #
//	14	#  ######  #
//	15	#  #----#  #
//	16	####----####
//	17	-##------##-
//		000000000011
//		012345678901
const char  chr84[]  = {0x54,0xaa,0x15,0x52,0x82,0x85,0x52,0x82,0x85,0x54,0x28,0x15,0x54,0xaa,0x15,0x52,0xaa,0x85,0x4a,0x82,0xa1,0x2a,0x00,0xa8,0x28,0x14,0x28,0x28,0x55,0x28,0x28,0x00,0x28,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x28,0x00,0x28,0x28,0x00,0x28,0x28,0x55,0x28,0x00,0x55,0x00,0x41,0x55,0x41};


//	 0	--------##--
//	 1	---#####  #-
//	 2	--#       #-
//	 3	-#       #--
//	 4	#   ###   ##
//	 5	#  ###  #  #
//	 6	#  #-#  #  #
//	 7	#  ##  ##  #
//	 8	#  ##  ##  #
//	 9	#  #  #-#  #
//	10	#  #  #-#  #
//	11	#    #--#  #
//	12	#    #--#  #
//	13	#   ####   #
//	14	##        ##
//	15	# #      ##-
//	16	# ########--
//	17	##-######---
//		000000000011
//		012345678901
const char  chr85[]  = {0x55,0x55,0x05,0x54,0x00,0xa1,0x52,0xaa,0xa1,0x4a,0xaa,0x85,0x2a,0x02,0xa0,0x28,0x0a,0x28,0x28,0x4a,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,0xa1,0x28,0x28,0xa1,0x28,0x2a,0x85,0x28,0x2a,0x85,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa0,0x22,0xaa,0x81,0x20,0x00,0x05,0x04,0x00,0x15};


//	 0	------------
//	 1	----########
//	 2	---#       #
//	 3	--#        #
//	 4	-#    ######
//	 5	##  # ######
//	 6	#  ## #-----
//	 7	# ##- ####--
//	 8	# #--     #-
//	 9	# ###     #-
//	10	#     #####-
//	11	#     ####--
//	12	# ### #-----
//	13	# ### ######
//	14	# #--      #
//	15	# #--      #
//	16	###--#######
//	17	-#---#######
//		000000000011
//		012345678901
const char  chr86[]  = {0x55,0x55,0x55,0x55,0x00,0x00,0x54,0xaa,0xa8,0x52,0xaa,0xa8,0x4a,0xa0,0x00,0x0a,0x20,0x00,0x28,0x21,0x55,0x20,0x60,0x05,0x21,0x6a,0xa1,0x20,0x2a,0xa1,0x2a,0xa0,0x01,0x2a,0xa0,0x05,0x20,0x21,0x55,0x20,0x20,0x00,0x21,0x6a,0xa8,0x21,0x6a,0xa8,0x01,0x40,0x00,0x45,0x40,0x00};


//	 0	---######---
//	 1	---#    #---
//	 2	--#  ##  #--
//	 3	---#    #---
//	 4	--########--
//	 5	--#      #--
//	 6	--#       #-
//	 7	--######   #
//	 8	---######  #
//	 9	--#     #  #
//	10	-#         #
//	11	#   ####   #
//	12	#  ######  #
//	13	#  #----#  #
//	14	#   ####   #
//	15	##         #
//	16	-##     #  #
//	17	--##########
//		000000000011
//		012345678901
const char  chr87[]  = {0x54,0x00,0x15,0x54,0xaa,0x15,0x52,0x82,0x85,0x54,0xaa,0x15,0x50,0x00,0x05,0x52,0xaa,0x85,0x52,0xaa,0xa1,0x50,0x00,0xa8,0x54,0x00,0x28,0x52,0xaa,0x28,0x4a,0xaa,0xa8,0x2a,0x00,0xa8,0x28,0x00,0x28,0x28,0x55,0x28,0x2a,0x00,0xa8,0x0a,0xaa,0xa8,0x42,0xaa,0x28,0x50,0x00,0x00};


//	 0	---#--------
//	 1	--# #-------
//	 2	--# #-------
//	 3	--# ####----
//	 4	--#     #---
//	 5	--######----
//	 6	---#   #----
//	 7	--# ### #---
//	 8	--#     #---
//	 9	--# ### #---
//	10	--# #-# #---
//	11	---#####----
//	12	--#     #---
//	13	---## ##----
//	14	----# #-----
//	15	----# #-----
//	16	----# #-----
//	17	-----#------
//		000000000011
//		012345678901
const char  chr88[]  = {0x54,0x55,0x55,0x52,0x15,0x55,0x52,0x15,0x55,0x52,0x00,0x55,0x52,0xaa,0x15,0x50,0x00,0x55,0x54,0xa8,0x55,0x52,0x02,0x15,0x52,0xaa,0x15,0x52,0x02,0x15,0x52,0x12,0x15,0x54,0x00,0x55,0x52,0xaa,0x15,0x54,0x20,0x55,0x55,0x21,0x55,0x55,0x21,0x55,0x55,0x21,0x55,0x55,0x45,0x55};


//	 0	----#-------
//	 1	---# #------
//	 2	---# #------
//	 3	---# ###----
//	 4	---#    #---
//	 5	----####----
//	 6	---# ## #---
//	 7	---# ## #---
//	 8	---#  # #---
//	 9	---# #  #---
//	10	---# ## #---
//	11	----####----
//	12	----#  ##---
//	13	---# ###----
//	14	---# #  #---
//	15	---# ## #---
//	16	----#  #----
//	17	-----##-----
//		000000000011
//		012345678901
const char  chr89[]  = {0x55,0x15,0x55,0x54,0x85,0x55,0x54,0x85,0x55,0x54,0x80,0x55,0x54,0xaa,0x15,0x55,0x00,0x55,0x54,0x82,0x15,0x54,0x82,0x15,0x54,0xa2,0x15,0x54,0x8a,0x15,0x54,0x82,0x15,0x55,0x00,0x55,0x55,0x28,0x15,0x54,0x80,0x55,0x54,0x8a,0x15,0x54,0x82,0x15,0x55,0x28,0x55,0x55,0x41,0x55};


//	 0	------------
//	 1	------------
//	 2	--####------
//	 3	-##  ##-----
//	 4	-# ## #-----
//	 5	-# ## #-----
//	 6	-#    #-----
//	 7	-# ## #-----
//	 8	-######-----
//	 9	-######-----
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char  chr90[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x50,0x05,0x55,0x42,0x81,0x55,0x48,0x21,0x55,0x48,0x21,0x55,0x4a,0xa1,0x55,0x48,0x21,0x55,0x40,0x01,0x55,0x40,0x01,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	--#########-
//	 3	-##  ##   ##
//	 4	-# ## # ## #
//	 5	-# ## # ## #
//	 6	-##  ## ## #
//	 7	-###########
//	 8	--##########
//	 9	-----###----
//	10	###### #####
//	11	    ####   #
//	12	 # # # # ##
//	13	 # # # # ##
//	14	 # # # # ##
//	15	############
//	16	############
//	17	------------
//		000000000011
//		012345678901
const char  chr91[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x50,0x00,0x01,0x42,0x82,0xa0,0x48,0x22,0x08,0x48,0x22,0x08,0x42,0x82,0x08,0x40,0x00,0x00,0x50,0x00,0x00,0x55,0x40,0x55,0x00,0x08,0x00,0xaa,0x00,0xa8,0x88,0x88,0x82,0x88,0x88,0x82,0x88,0x88,0x82,0x00,0x00,0x00,0x00,0x00,0x00,0x55,0x55,0x55};


//	 0	------------
//	 1	--#####-----
//	 2	-## # ######
//	 3	## ## # ## #
//	 4	#   # # ## #
//	 5	## ## # ## #
//	 6	## ## ##   #
//	 7	-######### #
//	 8	-#######  ##
//	 9	-----#######
//	10	###### #####
//	11	    ####   #
//	12	 # # # # ##
//	13	 # # # # ##
//	14	 # # # # ##
//	15	############
//	16	############
//	17	------------
//		000000000011
//		012345678901
const char  chr92[]  = {0x55,0x55,0x55,0x50,0x01,0x55,0x42,0x20,0x00,0x08,0x22,0x08,0x2a,0x22,0x08,0x08,0x22,0x08,0x08,0x20,0xa8,0x40,0x00,0x08,0x40,0x00,0xa0,0x55,0x40,0x00,0x00,0x08,0x00,0xaa,0x00,0xa8,0x88,0x88,0x82,0x88,0x88,0x82,0x88,0x88,0x82,0x00,0x00,0x00,0x00,0x00,0x00,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	-######-----
//	 3	-#    ##----
//	 4	-# # # #----
//	 5	-# # # #----
//	 6	-# # # #----
//	 7	-#######----
//	 8	-#######----
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char  chr93[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x40,0x01,0x55,0x4a,0xa0,0x55,0x48,0x88,0x55,0x48,0x88,0x55,0x48,0x88,0x55,0x40,0x00,0x55,0x40,0x00,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	--######----
//	 2	-## ## ##---
//	 3	## ##   #---
//	 4	#   ## ##---
//	 5	## ### ##---
//	 6	## #### #---
//	 7	-###-####---
//	 8	-###--###---
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char  chr94[]  = {0x55,0x55,0x55,0x50,0x00,0x55,0x42,0x08,0x15,0x08,0x2a,0x15,0x2a,0x08,0x15,0x08,0x08,0x15,0x08,0x02,0x15,0x40,0x40,0x15,0x40,0x50,0x15,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	######------
//	 3	#    ##-----
//	 4	# # # #-----
//	 5	# # # #-----
//	 6	# # # #-----
//	 7	#########---
//	 8	#       #---
//	 9	#########---
//	10	#########---
//	11	-##   #-----
//	12	-#  ###-----
//	13	-###  #-----
//	14	-#   ##-----
//	15	-######-----
//	16	-#####------
//	17	------------
//		000000000011
//		012345678901
const char  chr95[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x05,0x55,0x2a,0x81,0x55,0x22,0x21,0x55,0x22,0x21,0x55,0x22,0x21,0x55,0x00,0x00,0x15,0x2a,0xaa,0x15,0x00,0x00,0x15,0x00,0x00,0x15,0x42,0xa1,0x55,0x4a,0x01,0x55,0x40,0xa1,0x55,0x4a,0x81,0x55,0x40,0x01,0x55,0x40,0x05,0x55,0x55,0x55,0x55};


//	 0	-####-------
//	 1	##  ##------
//	 2	# ## #------
//	 3	# ## #------
//	 4	#    #------
//	 5	# ## #------
//	 6	######------
//	 7	##  ##------
//	 8	# ###-------
//	 9	# ###-------
//	10	##  #-------
//	11	#####-------
//	12	##  #-------
//	13	# ###-------
//	14	# ###-------
//	15	##  #-------
//	16	#####-------
//	17	-####-------
//		000000000011
//		012345678901
const char  chr96[]  = {0x40,0x15,0x55,0x0a,0x05,0x55,0x20,0x85,0x55,0x20,0x85,0x55,0x2a,0x85,0x55,0x20,0x85,0x55,0x00,0x05,0x55,0x0a,0x05,0x55,0x20,0x15,0x55,0x20,0x15,0x55,0x0a,0x15,0x55,0x00,0x15,0x55,0x0a,0x15,0x55,0x20,0x15,0x55,0x20,0x15,0x55,0x0a,0x15,0x55,0x00,0x15,0x55,0x40,0x15,0x55};


//	 0	# ### #-----
//	 1	#  #  #-----
//	 2	# # # #-----
//	 3	# ### #-----
//	 4	# ### #-----
//	 5	#######-----
//	 6	###   #-----
//	 7	-# ## #-----
//	 8	-# ## #-----
//	 9	-##   #-----
//	10	-######-----
//	11	-##   #-----
//	12	-# ## #-----
//	13	-# ## #-----
//	14	-##   #-----
//	15	-#### #-----
//	16	--#  ##-----
//	17	--#####-----
//		000000000011
//		012345678901
const char  chr97[]  = {0x20,0x21,0x55,0x28,0xa1,0x55,0x22,0x21,0x55,0x20,0x21,0x55,0x20,0x21,0x55,0x00,0x01,0x55,0x02,0xa1,0x55,0x48,0x21,0x55,0x48,0x21,0x55,0x42,0xa1,0x55,0x40,0x01,0x55,0x42,0xa1,0x55,0x48,0x21,0x55,0x48,0x21,0x55,0x42,0xa1,0x55,0x40,0x21,0x55,0x52,0x81,0x55,0x50,0x01,0x55};


//	 0	#####-------
//	 1	#   ##------
//	 2	# ## #------
//	 3	#   ##------
//	 4	# ## #------
//	 5	#   ##------
//	 6	######------
//	 7	##   #------
//	 8	# ## #------
//	 9	# ## #------
//	10	##   #------
//	11	######------
//	12	-# # #------
//	13	-#  ##------
//	14	-# ###------
//	15	-# ##-------
//	16	-###--------
//	17	-###--------
//		000000000011
//		012345678901
const char  chr98[]  = {0x00,0x15,0x55,0x2a,0x05,0x55,0x20,0x85,0x55,0x2a,0x05,0x55,0x20,0x85,0x55,0x2a,0x05,0x55,0x00,0x05,0x55,0x0a,0x85,0x55,0x20,0x85,0x55,0x20,0x85,0x55,0x0a,0x85,0x55,0x00,0x05,0x55,0x48,0x85,0x55,0x4a,0x05,0x55,0x48,0x05,0x55,0x48,0x15,0x55,0x40,0x55,0x55,0x40,0x55,0x55};


//	 0	-#####------
//	 1	##   #------
//	 2	# ####------
//	 3	# #  #------
//	 4	# ## #------
//	 5	##   #------
//	 6	######------
//	 7	#   ##------
//	 8	# ## #------
//	 9	# ## #------
//	10	#   ##------
//	11	# ####------
//	12	#    #------
//	13	#  ###------
//	14	###  #------
//	15	#   ##------
//	16	######------
//	17	#####-------
//		000000000011
//		012345678901
const char  chr99[]  = {0x40,0x05,0x55,0x0a,0x85,0x55,0x20,0x05,0x55,0x22,0x85,0x55,0x20,0x85,0x55,0x0a,0x85,0x55,0x00,0x05,0x55,0x2a,0x05,0x55,0x20,0x85,0x55,0x20,0x85,0x55,0x2a,0x05,0x55,0x20,0x05,0x55,0x2a,0x85,0x55,0x28,0x05,0x55,0x02,0x85,0x55,0x2a,0x05,0x55,0x00,0x05,0x55,0x00,0x15,0x55};


//	 0	------------
//	 1	-------####-
//	 2	########  ##
//	 3	#    ## ## #
//	 4	# # # # ## #
//	 5	# # # #    #
//	 6	# # # # ## #
//	 7	############
//	 8	############
//	 9	---###------
//	10	---# ###----
//	11	---#   ##---
//	12	---# ## #---
//	13	---# ## #---
//	14	---# ## #---
//	15	---######---
//	16	---######---
//	17	------------
//		000000000011
//		012345678901
const char chr100[]  = {0x55,0x55,0x55,0x55,0x54,0x01,0x00,0x00,0xa0,0x2a,0x82,0x08,0x22,0x22,0x08,0x22,0x22,0xa8,0x22,0x22,0x08,0x00,0x00,0x00,0x00,0x00,0x00,0x54,0x05,0x55,0x54,0x80,0x55,0x54,0xa8,0x15,0x54,0x82,0x15,0x54,0x82,0x15,0x54,0x82,0x15,0x54,0x00,0x15,0x54,0x00,0x15,0x55,0x55,0x55};


//	 0	------------
//	 1	###---------
//	 2	# #########-
//	 3	# ## #    ##
//	 4	# # ## # # #
//	 5	#   ## # # #
//	 6	# ## # # # #
//	 7	############
//	 8
//	 9	############
//	10	#### #######
//	11	---#   ##---
//	12	---# ## #---
//	13	---# ## #---
//	14	---# ## #---
//	15	---######---
//	16	---######---
//	17	------------
//		000000000011
//		012345678901
const char chr101[]  = {0x55,0x55,0x55,0x01,0x55,0x55,0x20,0x00,0x01,0x20,0x8a,0xa0,0x22,0x08,0x88,0x2a,0x08,0x88,0x20,0x88,0x88,0x00,0x00,0x00,0xaa,0xaa,0xaa,0x00,0x00,0x00,0x00,0x80,0x00,0x54,0xa8,0x15,0x54,0x82,0x15,0x54,0x82,0x15,0x54,0x82,0x15,0x54,0x00,0x15,0x54,0x00,0x15,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	###########-
//	 3	#    ##   ##
//	 4	# # # # ## #
//	 5	# # # # ## #
//	 6	# # # #   ##
//	 7	####### ####
//	 8
//	 9	############
//	10	#### #######
//	11	---#   ##---
//	12	---# ## #---
//	13	---# ## #---
//	14	---# ## #---
//	15	---######---
//	16	---######---
//	17	------------
//		000000000011
//		012345678901
const char chr102[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x00,0x01,0x2a,0x82,0xa0,0x22,0x22,0x08,0x22,0x22,0x08,0x22,0x22,0xa0,0x00,0x02,0x00,0xaa,0xaa,0xaa,0x00,0x00,0x00,0x00,0x80,0x00,0x54,0xa8,0x15,0x54,0x82,0x15,0x54,0x82,0x15,0x54,0x82,0x15,0x54,0x00,0x15,0x54,0x00,0x15,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	-##########-
//	 3	##  ## ## ##
//	 4	# ## # #   #
//	 5	# ## # ## ##
//	 6	#    # ## ##
//	 7	# ## # ### #
//	 8	############
//	 9	########-###
//	10	--######----
//	11	--#    ##---
//	12	--# # # #---
//	13	--# # # #---
//	14	--# # # #---
//	15	--#######---
//	16	--#######---
//	17	------------
//		000000000011
//		012345678901
const char chr103[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x40,0x00,0x01,0x0a,0x08,0x20,0x20,0x88,0xa8,0x20,0x88,0x20,0x2a,0x88,0x20,0x20,0x88,0x08,0x00,0x00,0x00,0x00,0x00,0x40,0x50,0x00,0x55,0x52,0xa8,0x15,0x52,0x22,0x15,0x52,0x22,0x15,0x52,0x22,0x15,0x50,0x00,0x15,0x50,0x00,0x15,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	-##########-
//	 3	##  ## ## ##
//	 4	# ## # #   #
//	 5	# ## # ## ##
//	 6	#    # ## ##
//	 7	# ## # ### #
//	 8	############
//	 9	############
//	10	--## ## ##--
//	11	-## ##   #--
//	12	-#   ## ##--
//	13	-## ### ##--
//	14	-## #### #--
//	15	--###-####--
//	16	--###--###--
//	17	------------
//		000000000011
//		012345678901
const char chr104[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x40,0x00,0x01,0x0a,0x08,0x20,0x20,0x88,0xa8,0x20,0x88,0x20,0x2a,0x88,0x20,0x20,0x88,0x08,0x00,0x00,0x00,0x00,0x00,0x00,0x50,0x82,0x05,0x42,0x0a,0x85,0x4a,0x82,0x05,0x42,0x02,0x05,0x42,0x00,0x85,0x50,0x10,0x05,0x50,0x14,0x05,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	-######-----
//	 3	-# ## #-----
//	 4	-# ## #-----
//	 5	-# # ##-----
//	 6	-# # ##-----
//	 7	-## ##------
//	 8	-#####------
//	 9	--###-------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr105[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x40,0x01,0x55,0x48,0x21,0x55,0x48,0x21,0x55,0x48,0x81,0x55,0x48,0x81,0x55,0x42,0x05,0x55,0x40,0x05,0x55,0x50,0x15,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	---####-----
//	 2	--##  ######
//	 3	--# ## # ##
//	 4	--# ## # ##
//	 5	--#    # ##
//	 6	--# ## ##  #
//	 7	--##########
//	 8	--##########
//	 9	-##--###----
//	10	-# ### #####
//	11	-#  #  ##  #
//	12	-# # # # ##
//	13	-# ### # ##
//	14	-# #-# ##  #
//	15	-###-#######
//	16	-###-#######
//	17	------------
//		000000000011
//		012345678901
const char chr106[]  = {0x55,0x55,0x55,0x54,0x01,0x55,0x50,0xa0,0x00,0x52,0x08,0x82,0x52,0x08,0x82,0x52,0xa8,0x82,0x52,0x08,0x28,0x50,0x00,0x00,0x50,0x00,0x00,0x41,0x40,0x55,0x48,0x08,0x00,0x4a,0x28,0x28,0x48,0x88,0x82,0x48,0x08,0x82,0x48,0x48,0x28,0x40,0x40,0x00,0x40,0x40,0x00,0x55,0x55,0x55};


//	 0	------------
//	 1	-###--------
//	 2	## ######---
//	 3	#   ##  ##--
//	 4	## ## ## #--
//	 5	## ## ## #--
//	 6	### ##  ##--
//	 7	##########--
//	 8	#########---
//	 9	---###------
//	10	-### #####--
//	11	##   ##  ##-
//	12	# ## # #  #-
//	13	# ## #  ###-
//	14	##   ##  ##-
//	15	##########--
//	16	-#########--
//	17	------------
//		000000000011
//		012345678901
const char chr107[]  = {0x55,0x55,0x55,0x40,0x55,0x55,0x08,0x00,0x15,0x2a,0x0a,0x05,0x08,0x20,0x85,0x08,0x20,0x85,0x02,0x0a,0x05,0x00,0x00,0x05,0x00,0x00,0x15,0x54,0x05,0x55,0x40,0x80,0x05,0x0a,0x82,0x81,0x20,0x88,0xa1,0x20,0x8a,0x01,0x0a,0x82,0x81,0x00,0x00,0x05,0x40,0x00,0x05,0x55,0x55,0x55};


//	 0	------------
//	 1	#######-----
//	 2	#   # ######
//	 3	 ###   #
//	 4	#  ## ## ##
//	 5	### # ## ##
//	 6	   ### ##
//	 7	####-#######
//	 8	####-#######
//	 9	-###-###----
//	10	-# ### #####
//	11	-#  #  ##  #
//	12	-# # # # ##
//	13	-# ### # ##
//	14	-# #-# ##  #
//	15	-###-#######
//	16	-###-#######
//	17	------------
//		000000000011
//		012345678901
const char chr108[]  = {0x55,0x55,0x55,0x00,0x01,0x55,0x2a,0x20,0x00,0x80,0xa8,0xaa,0x28,0x20,0x82,0x02,0x20,0x82,0xa8,0x08,0x2a,0x00,0x40,0x00,0x00,0x40,0x00,0x40,0x40,0x55,0x48,0x08,0x00,0x4a,0x28,0x28,0x48,0x88,0x82,0x48,0x08,0x82,0x48,0x48,0x28,0x40,0x40,0x00,0x40,0x40,0x00,0x55,0x55,0x55};


//	 0	------------
//	 1	###--###----
//	 2	# #### #####
//	 3	#    # ##  #
//	 4	# ## # # #
//	 5	# ## # #  ##
//	 6	#   ## ##  #
//	 7	############
//	 8	############
//	 9	---###------
//	10	-### #####--
//	11	##   ##  ##-
//	12	# ## # #  #-
//	13	# ## #  ###-
//	14	##   ##  ##-
//	15	##########--
//	16	-#########--
//	17	------------
//		000000000011
//		012345678901
const char chr109[]  = {0x55,0x55,0x55,0x01,0x40,0x55,0x20,0x08,0x00,0x2a,0x88,0x28,0x20,0x88,0x8a,0x20,0x88,0xa0,0x2a,0x08,0x28,0x00,0x00,0x00,0x00,0x00,0x00,0x54,0x05,0x55,0x40,0x80,0x05,0x0a,0x82,0x81,0x20,0x88,0xa1,0x20,0x8a,0x01,0x0a,0x82,0x81,0x00,0x00,0x05,0x40,0x00,0x05,0x55,0x55,0x55};


//	 0	------------
//	 1	-###-###----
//	 2	-# ### #####
//	 3	-#  #  #
//	 4	-# # # # ##
//	 5	-# ### # ##
//	 6	-# ### ##
//	 7	-###########
//	 8	-###########
//	 9	-###-###----
//	10	-# ### #####
//	11	-#  #  ##  #
//	12	-# # # # ##
//	13	-# ### # ##
//	14	-# #-# ##  #
//	15	-###-#######
//	16	-###-#######
//	17	------------
//		000000000011
//		012345678901
const char chr110[]  = {0x55,0x55,0x55,0x40,0x40,0x55,0x48,0x08,0x00,0x4a,0x28,0xaa,0x48,0x88,0x82,0x48,0x08,0x82,0x48,0x08,0x2a,0x40,0x00,0x00,0x40,0x00,0x00,0x40,0x40,0x55,0x48,0x08,0x00,0x4a,0x28,0x28,0x48,0x88,0x82,0x48,0x08,0x82,0x48,0x48,0x28,0x40,0x40,0x00,0x40,0x40,0x00,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	###########-
//	 3	# # ## ## #-
//	 4	#  # # ## #-
//	 5	# ## # ## #-
//	 6	# ## ##  ##-
//	 7	###########-
//	 8	##########--
//	 9	---###------
//	10	-### #####--
//	11	#    ##  ##-
//	12	# ## # #  #-
//	13	# ## #  ###-
//	14	##   ##  ##-
//	15	##########--
//	16	-#########--
//	17	------------
//		000000000011
//		012345678901
const char chr111[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x00,0x01,0x22,0x08,0x21,0x28,0x88,0x21,0x20,0x88,0x21,0x20,0x82,0x81,0x00,0x00,0x01,0x00,0x00,0x05,0x54,0x05,0x55,0x40,0x80,0x05,0x2a,0x82,0x81,0x20,0x88,0xa1,0x20,0x8a,0x01,0x0a,0x82,0x81,0x00,0x00,0x05,0x40,0x00,0x05,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	------------
//	 8	------------
//	 9	------------
//	10	------------
//	11	-----##-----
//	12	----#  #----
//	13	---#    #---
//	14	--#      #--
//	15	-#        #-
//	16	#          #
//	17	############
//		000000000011
//		012345678901
const char chr112[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x54,0xaa,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0xaa,0xa8,0x00,0x00,0x00};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	-----##-----
//	 6	----#  #----
//	 7	---#    #---
//	 8	--#      #--
//	 9	-#        #-
//	10	#          #
//	11	############
//	12	----#  #----
//	13	---#    #---
//	14	--#      #--
//	15	-#        #-
//	16	#          #
//	17	############
//		000000000011
//		012345678901
const char chr113[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x54,0xaa,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0xaa,0xa8,0x00,0x00,0x00,0x55,0x28,0x55,0x54,0xaa,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0xaa,0xa8,0x00,0x00,0x00};


//	 0	----#  #----
//	 1	---#    #---
//	 2	--#      #--
//	 3	-#        #-
//	 4	#          #
//	 5	############
//	 6	----#  #----
//	 7	---#    #---
//	 8	--#      #--
//	 9	-#        #-
//	10	#          #
//	11	############
//	12	----#  #----
//	13	---#    #---
//	14	--#      #--
//	15	-#        #-
//	16	#          #
//	17	############
//		000000000011
//		012345678901
const char chr114[]  = {0x55,0x28,0x55,0x54,0xaa,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0xaa,0xa8,0x00,0x00,0x00,0x55,0x28,0x55,0x54,0xaa,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0xaa,0xa8,0x00,0x00,0x00,0x55,0x28,0x55,0x54,0xaa,0x15,0x52,0xaa,0x85,0x4a,0xaa,0xa1,0x2a,0xaa,0xa8,0x00,0x00,0x00};


//	 0	----####----
//	 1	---######---
//	 2	--########--
//	 3	-##########-
//	 4	############
//	 5	############
//	 6	----####----
//	 7	---######---
//	 8	--########--
//	 9	-##########-
//	10	############
//	11	############
//	12	----####----
//	13	---######---
//	14	--########--
//	15	-##########-
//	16	############
//	17	############
//		000000000011
//		012345678901
const char chr115[]  = {0x55,0x00,0x55,0x54,0x00,0x15,0x50,0x00,0x05,0x40,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x55,0x00,0x55,0x54,0x00,0x15,0x50,0x00,0x05,0x40,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x55,0x00,0x55,0x54,0x00,0x15,0x50,0x00,0x05,0x40,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x00};


//	 0	############
//	 1	############
//	 2	-##########-
//	 3	--########--
//	 4	---######---
//	 5	----####----
//	 6	############
//	 7	############
//	 8	-##########-
//	 9	--########--
//	10	---######---
//	11	----####----
//	12	############
//	13	############
//	14	-##########-
//	15	--########--
//	16	---######---
//	17	----####----
//		000000000011
//		012345678901
const char chr116[]  = {0x00,0x00,0x00,0x00,0x00,0x00,0x40,0x00,0x01,0x50,0x00,0x05,0x54,0x00,0x15,0x55,0x00,0x55,0x00,0x00,0x00,0x00,0x00,0x00,0x40,0x00,0x01,0x50,0x00,0x05,0x54,0x00,0x15,0x55,0x00,0x55,0x00,0x00,0x00,0x00,0x00,0x00,0x40,0x00,0x01,0x50,0x00,0x05,0x54,0x00,0x15,0x55,0x00,0x55};


//	 0	############
//	 1	#          #
//	 2	-#        #-
//	 3	--#      #--
//	 4	---#    #---
//	 5	----#  #----
//	 6	############
//	 7	#          #
//	 8	-#        #-
//	 9	--#      #--
//	10	---#    #---
//	11	----#  #----
//	12	############
//	13	#          #
//	14	-#        #-
//	15	--#      #--
//	16	---#    #---
//	17	----#  #----
//		000000000011
//		012345678901
const char chr117[]  = {0x00,0x00,0x00,0x2a,0xaa,0xa8,0x4a,0xaa,0xa1,0x52,0xaa,0x85,0x54,0xaa,0x15,0x55,0x28,0x55,0x00,0x00,0x00,0x2a,0xaa,0xa8,0x4a,0xaa,0xa1,0x52,0xaa,0x85,0x54,0xaa,0x15,0x55,0x28,0x55,0x00,0x00,0x00,0x2a,0xaa,0xa8,0x4a,0xaa,0xa1,0x52,0xaa,0x85,0x54,0xaa,0x15,0x55,0x28,0x55};


//	 0	############
//	 1	#          #
//	 2	-#        #-
//	 3	--#      #--
//	 4	---#    #---
//	 5	----#  #----
//	 6	############
//	 7	#          #
//	 8	-#        #-
//	 9	--#      #--
//	10	---#    #---
//	11	----#  #----
//	12	-----##-----
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr118[]  = {0x00,0x00,0x00,0x2a,0xaa,0xa8,0x4a,0xaa,0xa1,0x52,0xaa,0x85,0x54,0xaa,0x15,0x55,0x28,0x55,0x00,0x00,0x00,0x2a,0xaa,0xa8,0x4a,0xaa,0xa1,0x52,0xaa,0x85,0x54,0xaa,0x15,0x55,0x28,0x55,0x55,0x41,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	############
//	 1	#          #
//	 2	-#        #-
//	 3	--#      #--
//	 4	---#    #---
//	 5	----#  #----
//	 6	-----##-----
//	 7	------------
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr119[]  = {0x00,0x00,0x00,0x2a,0xaa,0xa8,0x4a,0xaa,0xa1,0x52,0xaa,0x85,0x54,0xaa,0x15,0x55,0x28,0x55,0x55,0x41,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	-##########-
//	 1	#          #
//	 2	#          #
//	 3	-##########-
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	------------
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr120[]  = {0x40,0x00,0x01,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x40,0x00,0x01,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	-##########-
//	 5	#          #
//	 6	#          #
//	 7	-##########-
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr121[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x40,0x00,0x01,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x40,0x00,0x01,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	-##########-
//	 8	#          #
//	 9	#          #
//	10	-##########-
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr122[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x40,0x00,0x01,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x40,0x00,0x01,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	------------
//	 8	------------
//	 9	------------
//	10	-##########-
//	11	#          #
//	12	#          #
//	13	-##########-
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr123[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x40,0x00,0x01,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x40,0x00,0x01,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	------------
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	-##########-
//	15	#          #
//	16	#          #
//	17	-##########-
//		000000000011
//		012345678901
const char chr124[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x40,0x00,0x01,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x40,0x00,0x01};


//	 0	--####------
//	 1	-#    #-----
//	 2	# #### #----
//	 3	# #--# #----
//	 4	# #--# #----
//	 5	# #### #----
//	 6	-#    #-----
//	 7	--####------
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr125[]  = {0x50,0x05,0x55,0x4a,0xa1,0x55,0x20,0x08,0x55,0x21,0x48,0x55,0x21,0x48,0x55,0x20,0x08,0x55,0x4a,0xa1,0x55,0x50,0x05,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	-----##-----
//	 1	----#  #----
//	 2	---#    #---
//	 3	--#      #--
//	 4	--########--
//	 5	------------
//	 6	------------
//	 7	------------
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr126[]  = {0x55,0x41,0x55,0x55,0x28,0x55,0x54,0xaa,0x15,0x52,0xaa,0x85,0x50,0x00,0x05,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	###########-
//	 1	#         ##
//	 2	# # #  #  ##
//	 3	# # # # # ##
//	 4	# ### # # ##
//	 5	# # # # # ##
//	 6	# # #  #  ##
//	 7	#         ##
//	 8	# #   ##  ##
//	 9	# #   # # ##
//	10	# #   # # ##
//	11	# #   # # ##
//	12	# ### ##  ##
//	13	#         ##
//	14	############
//	15	-###########
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr127[]  = {0x00,0x00,0x01,0x2a,0xaa,0xa0,0x22,0x28,0xa0,0x22,0x22,0x20,0x20,0x22,0x20,0x22,0x22,0x20,0x22,0x28,0xa0,0x2a,0xaa,0xa0,0x22,0xa0,0xa0,0x22,0xa2,0x20,0x22,0xa2,0x20,0x22,0xa2,0x20,0x20,0x20,0xa0,0x2a,0xaa,0xa0,0x00,0x00,0x00,0x40,0x00,0x00,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ## ### --
//	 4	- #   #  # -
//	 5	 #    #   #
//	 6	#     #    #
//	 7	#     #    #
//	 8	      #
//	 9	      #
//	10	#          #
//	11	#          #
//	12	 #        #
//	13	- #      # -
//	14	-- ##  ## --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr128[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x20,0x25,0x62,0xa2,0x89,0x8a,0xa2,0xa2,0x2a,0xa2,0xa8,0x2a,0xa2,0xa8,0xaa,0xa2,0xaa,0xaa,0xa2,0xaa,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x8a,0xaa,0xa2,0x62,0xaa,0x89,0x58,0x28,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ## ### --
//	 4	- #   #### -
//	 5	 #    ### #
//	 6	#     ##   #
//	 7	#     ##   #
//	 8	      #
//	 9	      #
//	10	#          #
//	11	#          #
//	12	 #        #
//	13	- #      # -
//	14	-- ##  ## --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr129[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x20,0x25,0x62,0xa0,0x09,0x8a,0xa0,0x22,0x2a,0xa0,0xa8,0x2a,0xa0,0xa8,0xaa,0xa2,0xaa,0xaa,0xa2,0xaa,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x8a,0xaa,0xa2,0x62,0xaa,0x89,0x58,0x28,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ## ### --
//	 4	- #   #### -
//	 5	 #    #####
//	 6	#     #### #
//	 7	#     ###  #
//	 8	      ##
//	 9	      #
//	10	#          #
//	11	#          #
//	12	 #        #
//	13	- #      # -
//	14	-- ##  ## --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr130[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x20,0x25,0x62,0xa0,0x09,0x8a,0xa0,0x02,0x2a,0xa0,0x08,0x2a,0xa0,0x28,0xaa,0xa0,0xaa,0xaa,0xa2,0xaa,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x8a,0xaa,0xa2,0x62,0xaa,0x89,0x58,0x28,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ## ### --
//	 4	- #   #### -
//	 5	 #    #####
//	 6	#     ######
//	 7	#     #### #
//	 8	      ###
//	 9	      #
//	10	#          #
//	11	#          #
//	12	 #        #
//	13	- #      # -
//	14	-- ##  ## --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr131[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x20,0x25,0x62,0xa0,0x09,0x8a,0xa0,0x02,0x2a,0xa0,0x00,0x2a,0xa0,0x08,0xaa,0xa0,0x2a,0xaa,0xa2,0xaa,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x8a,0xaa,0xa2,0x62,0xaa,0x89,0x58,0x28,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ## ### --
//	 4	- #   #### -
//	 5	 #    #####
//	 6	#     ######
//	 7	#     ######
//	 8	      #####
//	 9	      #####
//	10	#          #
//	11	#          #
//	12	 #        #
//	13	- #      # -
//	14	-- ##  ## --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr132[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x20,0x25,0x62,0xa0,0x09,0x8a,0xa0,0x02,0x2a,0xa0,0x00,0x2a,0xa0,0x00,0xaa,0xa0,0x02,0xaa,0xa0,0x02,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x8a,0xaa,0xa2,0x62,0xaa,0x89,0x58,0x28,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ## ### --
//	 4	- #   #### -
//	 5	 #    #####
//	 6	#     ######
//	 7	#     ######
//	 8	      ######
//	 9	      ######
//	10	#      #####
//	11	#        ###
//	12	 #        #
//	13	- #      # -
//	14	-- ##  ## --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr133[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x20,0x25,0x62,0xa0,0x09,0x8a,0xa0,0x02,0x2a,0xa0,0x00,0x2a,0xa0,0x00,0xaa,0xa0,0x00,0xaa,0xa0,0x00,0x2a,0xa8,0x00,0x2a,0xaa,0x80,0x8a,0xaa,0xa2,0x62,0xaa,0x89,0x58,0x28,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ## ### --
//	 4	- #   #### -
//	 5	 #    #####
//	 6	#     ######
//	 7	#     ######
//	 8	      ######
//	 9	      ######
//	10	#     ######
//	11	#      #####
//	12	 #      ###
//	13	- #      # -
//	14	-- ##  ## --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr134[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x20,0x25,0x62,0xa0,0x09,0x8a,0xa0,0x02,0x2a,0xa0,0x00,0x2a,0xa0,0x00,0xaa,0xa0,0x00,0xaa,0xa0,0x00,0x2a,0xa0,0x00,0x2a,0xa8,0x00,0x8a,0xaa,0x02,0x62,0xaa,0x89,0x58,0x28,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ## ### --
//	 4	- #   #### -
//	 5	 #    #####
//	 6	#     ######
//	 7	#     ######
//	 8	      ######
//	 9	      ######
//	10	#     ######
//	11	#     ######
//	12	 #     ####
//	13	- #     ## -
//	14	-- ##  ## --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr135[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x20,0x25,0x62,0xa0,0x09,0x8a,0xa0,0x02,0x2a,0xa0,0x00,0x2a,0xa0,0x00,0xaa,0xa0,0x00,0xaa,0xa0,0x00,0x2a,0xa0,0x00,0x2a,0xa0,0x00,0x8a,0xa8,0x02,0x62,0xaa,0x09,0x58,0x28,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ## ### --
//	 4	- #   #### -
//	 5	 #    #####
//	 6	#     ######
//	 7	#     ######
//	 8	      ######
//	 9	      ######
//	10	#     ######
//	11	#     ######
//	12	 #    #####
//	13	- #   #### -
//	14	-- ## ### --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr136[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x20,0x25,0x62,0xa0,0x09,0x8a,0xa0,0x02,0x2a,0xa0,0x00,0x2a,0xa0,0x00,0xaa,0xa0,0x00,0xaa,0xa0,0x00,0x2a,0xa0,0x00,0x2a,0xa0,0x00,0x8a,0xa0,0x02,0x62,0xa0,0x09,0x58,0x20,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ## ### --
//	 4	- #   #### -
//	 5	 #    #####
//	 6	#     ######
//	 7	#     ######
//	 8	      ######
//	 9	     #######
//	10	#   ########
//	11	#   ########
//	12	 # ########
//	13	- ######## -
//	14	-- ###### --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr137[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x20,0x25,0x62,0xa0,0x09,0x8a,0xa0,0x02,0x2a,0xa0,0x00,0x2a,0xa0,0x00,0xaa,0xa0,0x00,0xaa,0x80,0x00,0x2a,0x00,0x00,0x2a,0x00,0x00,0x88,0x00,0x02,0x60,0x00,0x09,0x58,0x00,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ## ### --
//	 4	- #   #### -
//	 5	 #    #####
//	 6	#     ######
//	 7	#     ######
//	 8	     #######
//	 9	    ########
//	10	#  #########
//	11	# ##########
//	12	 ##########
//	13	- ######## -
//	14	-- ###### --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr138[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x20,0x25,0x62,0xa0,0x09,0x8a,0xa0,0x02,0x2a,0xa0,0x00,0x2a,0xa0,0x00,0xaa,0x80,0x00,0xaa,0x00,0x00,0x28,0x00,0x00,0x20,0x00,0x00,0x80,0x00,0x02,0x60,0x00,0x09,0x58,0x00,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ## ### --
//	 4	- #   #### -
//	 5	 #    #####
//	 6	#     ######
//	 7	#     ######
//	 8	     #######
//	 9	   #########
//	10	# ##########
//	11	############
//	12	 ##########
//	13	- ######## -
//	14	-- ###### --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr139[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x20,0x25,0x62,0xa0,0x09,0x8a,0xa0,0x02,0x2a,0xa0,0x00,0x2a,0xa0,0x00,0xaa,0x80,0x00,0xa8,0x00,0x00,0x20,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0x02,0x60,0x00,0x09,0x58,0x00,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ## ### --
//	 4	- #   #### -
//	 5	 #    #####
//	 6	#     ######
//	 7	#     ######
//	 8	 ###########
//	 9	 ###########
//	10	############
//	11	############
//	12	 ##########
//	13	- ######## -
//	14	-- ###### --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr140[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x20,0x25,0x62,0xa0,0x09,0x8a,0xa0,0x02,0x2a,0xa0,0x00,0x2a,0xa0,0x00,0x80,0x00,0x00,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0x02,0x60,0x00,0x09,0x58,0x00,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ## ### --
//	 4	- #   #### -
//	 5	 #    #####
//	 6	###   ######
//	 7	##### ######
//	 8	############
//	 9	############
//	10	############
//	11	############
//	12	 ##########
//	13	- ######## -
//	14	-- ###### --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr141[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x20,0x25,0x62,0xa0,0x09,0x8a,0xa0,0x02,0x02,0xa0,0x00,0x00,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0x02,0x60,0x00,0x09,0x58,0x00,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ## ### --
//	 4	- #   #### -
//	 5	 ###  #####
//	 6	##### ######
//	 7	############
//	 8	############
//	 9	############
//	10	############
//	11	############
//	12	 ##########
//	13	- ######## -
//	14	-- ###### --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr142[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x20,0x25,0x62,0xa0,0x09,0x80,0xa0,0x02,0x00,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0x02,0x60,0x00,0x09,0x58,0x00,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ###### --
//	 4	- ######## -
//	 5	 ##########
//	 6	############
//	 7	############
//	 8	############
//	 9	############
//	10	############
//	11	############
//	12	 ##########
//	13	- ######## -
//	14	-- ###### --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr143[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x00,0x25,0x60,0x00,0x09,0x80,0x00,0x02,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0x02,0x60,0x00,0x09,0x58,0x00,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-# ###### #-
//	 4	-# ###### #-
//	 5	-# ###### #-
//	 6	-# ###### #-
//	 7	-# ###### #-
//	 8	-# ###### #-
//	 9	-# ###### #-
//	10	-# ###### #-
//	11	-# ###### #-
//	12	-# ###### #-
//	13	-# ###### #-
//	14	-# ###### #-
//	15	-# ###### #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr144[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-#   ##   #-
//	 4	-# ###### #-
//	 5	-# ###### #-
//	 6	-# ###### #-
//	 7	-# ###### #-
//	 8	-# ###### #-
//	 9	-# ###### #-
//	10	-# ###### #-
//	11	-# ###### #-
//	12	-# ###### #-
//	13	-# ###### #-
//	14	-# ###### #-
//	15	-# ###### #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr145[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x4a,0x82,0xa1,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-#   ##   #-
//	 4	-#        #-
//	 5	-# ###### #-
//	 6	-# ###### #-
//	 7	-# ###### #-
//	 8	-# ###### #-
//	 9	-# ###### #-
//	10	-# ###### #-
//	11	-# ###### #-
//	12	-# ###### #-
//	13	-# ###### #-
//	14	-# ###### #-
//	15	-# ###### #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr146[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x4a,0x82,0xa1,0x4a,0xaa,0xa1,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-#   ##   #-
//	 4	-#        #-
//	 5	-#        #-
//	 6	-# ###### #-
//	 7	-# ###### #-
//	 8	-# ###### #-
//	 9	-# ###### #-
//	10	-# ###### #-
//	11	-# ###### #-
//	12	-# ###### #-
//	13	-# ###### #-
//	14	-# ###### #-
//	15	-# ###### #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr147[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x4a,0x82,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-#   ##   #-
//	 4	-#        #-
//	 5	-#        #-
//	 6	-#        #-
//	 7	-# ###### #-
//	 8	-# ###### #-
//	 9	-# ###### #-
//	10	-# ###### #-
//	11	-# ###### #-
//	12	-# ###### #-
//	13	-# ###### #-
//	14	-# ###### #-
//	15	-# ###### #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr148[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x4a,0x82,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-#   ##   #-
//	 4	-#        #-
//	 5	-#        #-
//	 6	-#        #-
//	 7	-#        #-
//	 8	-# ###### #-
//	 9	-# ###### #-
//	10	-# ###### #-
//	11	-# ###### #-
//	12	-# ###### #-
//	13	-# ###### #-
//	14	-# ###### #-
//	15	-# ###### #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr149[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x4a,0x82,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-#   ##   #-
//	 4	-#        #-
//	 5	-#        #-
//	 6	-#        #-
//	 7	-#        #-
//	 8	-#        #-
//	 9	-# ###### #-
//	10	-# ###### #-
//	11	-# ###### #-
//	12	-# ###### #-
//	13	-# ###### #-
//	14	-# ###### #-
//	15	-# ###### #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr150[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x4a,0x82,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-#   ##   #-
//	 4	-#        #-
//	 5	-#        #-
//	 6	-#        #-
//	 7	-#        #-
//	 8	-#        #-
//	 9	-#        #-
//	10	-# ###### #-
//	11	-# ###### #-
//	12	-# ###### #-
//	13	-# ###### #-
//	14	-# ###### #-
//	15	-# ###### #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr151[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x4a,0x82,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-#   ##   #-
//	 4	-#        #-
//	 5	-#        #-
//	 6	-#        #-
//	 7	-#        #-
//	 8	-#        #-
//	 9	-#        #-
//	10	-#        #-
//	11	-# ###### #-
//	12	-# ###### #-
//	13	-# ###### #-
//	14	-# ###### #-
//	15	-# ###### #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr152[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x4a,0x82,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-#   ##   #-
//	 4	-#        #-
//	 5	-#        #-
//	 6	-#        #-
//	 7	-#        #-
//	 8	-#        #-
//	 9	-#        #-
//	10	-#        #-
//	11	-#        #-
//	12	-# ###### #-
//	13	-# ###### #-
//	14	-# ###### #-
//	15	-# ###### #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr153[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x4a,0x82,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-#   ##   #-
//	 4	-#        #-
//	 5	-#        #-
//	 6	-#        #-
//	 7	-#        #-
//	 8	-#        #-
//	 9	-#        #-
//	10	-#        #-
//	11	-#        #-
//	12	-#        #-
//	13	-# ###### #-
//	14	-# ###### #-
//	15	-# ###### #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr154[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x4a,0x82,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-#   ##   #-
//	 4	-#        #-
//	 5	-#        #-
//	 6	-#        #-
//	 7	-#        #-
//	 8	-#        #-
//	 9	-#        #-
//	10	-#        #-
//	11	-#        #-
//	12	-#        #-
//	13	-#        #-
//	14	-# ###### #-
//	15	-# ###### #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr155[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x4a,0x82,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x48,0x00,0x21,0x48,0x00,0x21,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-#   ##   #-
//	 4	-#        #-
//	 5	-#        #-
//	 6	-#        #-
//	 7	-#        #-
//	 8	-#        #-
//	 9	-#        #-
//	10	-#        #-
//	11	-#        #-
//	12	-#        #-
//	13	-#        #-
//	14	-#        #-
//	15	-# ###### #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr156[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x4a,0x82,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x48,0x00,0x21,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-#   ##   #-
//	 4	-#        #-
//	 5	-#        #-
//	 6	-#        #-
//	 7	-#        #-
//	 8	-#        #-
//	 9	-#        #-
//	10	-#        #-
//	11	-#        #-
//	12	-#        #-
//	13	-#        #-
//	14	-#        #-
//	15	-#        #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr157[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x4a,0x82,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ##  ## --
//	 4	- #      # -
//	 5	 #        #
//	 6	#       ## #
//	 7	#  ##  ##  #
//	 8	    ####
//	 9	     ##
//	10	#          #
//	11	#          #
//	12	 #        #
//	13	- #      # -
//	14	-- ##  ## --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr158[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x28,0x25,0x62,0xaa,0x89,0x8a,0xaa,0xa2,0x2a,0xaa,0x08,0x28,0x28,0x28,0xaa,0x00,0xaa,0xaa,0x82,0xaa,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x8a,0xaa,0xa2,0x62,0xaa,0x89,0x58,0x28,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1
//	 2	############
//	 3	##   ##  ###
//	 4	#### ## # ##
//	 5	###  ## # ##
//	 6	#### ## # ##
//	 7	##   ##  ###
//	 8	############
//	 9	##   # #####
//	10	## #########
//	11	##  ## # # #
//	12	## ### ## ##
//	13	## ### # # #
//	14	############
//	15
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr159[]  = {0x55,0x55,0x55,0xaa,0xaa,0xaa,0x00,0x00,0x00,0x0a,0x82,0x80,0x00,0x82,0x20,0x02,0x82,0x20,0x00,0x82,0x20,0x0a,0x82,0x80,0x00,0x00,0x00,0x0a,0x88,0x00,0x08,0x00,0x00,0x0a,0x08,0x88,0x08,0x08,0x20,0x08,0x08,0x88,0x00,0x00,0x00,0xaa,0xaa,0xaa,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----------#
//	 2	----------#
//	 3	---------#
//	 4	---------#
//	 5	---------#
//	 6	---#####-#
//	 7	--#     ##
//	 8	--#
//	 9	---##
//	10	---###
//	11	----####
//	12	-----####
//	13	------#####
//	14	--------####
//	15	---------###
//	16	----------##
//	17	------------
//		000000000011
//		012345678901
const char chr160[]  = {0x55,0x55,0x55,0x55,0x55,0x54,0x55,0x55,0x52,0x55,0x55,0x4a,0x55,0x55,0x4a,0x55,0x55,0x4a,0x54,0x00,0x4a,0x52,0xaa,0x0a,0x52,0xaa,0xaa,0x54,0x2a,0xaa,0x54,0x0a,0xaa,0x55,0x00,0xaa,0x55,0x40,0x2a,0x55,0x50,0x02,0x55,0x55,0x00,0x55,0x55,0x40,0x55,0x55,0x50,0x55,0x55,0x55};


//	 0	------------
//	 1	#-----------
//	 2	 ##---------
//	 3	  #---------
//	 4	  #---------
//	 5	  #---------
//	 6	  #-#####---
//	 7	  ##     #--
//	 8	         #--
//	 9	       ##---
//	10	      ###---
//	11	    ####----
//	12	   ####-----
//	13	 #####------
//	14	####--------
//	15	###---------
//	16	##----------
//	17	------------
//		000000000011
//		012345678901
const char chr161[]  = {0x55,0x55,0x55,0x15,0x55,0x55,0x81,0x55,0x55,0xa1,0x55,0x55,0xa1,0x55,0x55,0xa1,0x55,0x55,0xa1,0x00,0x15,0xa0,0xaa,0x85,0xaa,0xaa,0x85,0xaa,0xa8,0x15,0xaa,0xa0,0x15,0xaa,0x00,0x55,0xa8,0x01,0x55,0x80,0x05,0x55,0x00,0x55,0x55,0x01,0x55,0x55,0x05,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	-----####---
//	 3	----#    ##-
//	 4	----##     #
//	 5	-----###
//	 6	-----#####
//	 7	-------#####
//	 8	-------#####
//	 9	------#
//	10	------#
//	11	------#
//	12	-------#####
//	13	-------#####
//	14	--------####
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr162[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x40,0x15,0x55,0x2a,0x81,0x55,0x0a,0xa8,0x55,0x40,0xaa,0x55,0x40,0x0a,0x55,0x54,0x00,0x55,0x54,0x00,0x55,0x52,0xaa,0x55,0x52,0xaa,0x55,0x52,0xaa,0x55,0x54,0x00,0x55,0x54,0x00,0x55,0x55,0x00,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	#--#####----
//	 5	  ##    #---
//	 6	         #--
//	 7	         #--
//	 8	          #-
//	 9	          #-
//	10	          #-
//	11	         ##-
//	12	###########-
//	13	##########--
//	14	####--------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr163[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x14,0x00,0x55,0xa0,0xaa,0x15,0xaa,0xaa,0x85,0xaa,0xaa,0x85,0xaa,0xaa,0xa1,0xaa,0xaa,0xa1,0xaa,0xaa,0xa1,0xaa,0xaa,0x81,0x00,0x00,0x01,0x00,0x00,0x05,0x00,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	--##########
//	 5	###
//	 6	#
//	 7	############
//	 8	-###########
//	 9	-###########
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr164[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x50,0x00,0x00,0x02,0xaa,0xaa,0x2a,0xaa,0xaa,0x00,0x00,0x00,0x40,0x00,0x00,0x40,0x00,0x00,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	#####-------
//	 3	#   ###-----
//	 4	###   ####--
//	 5	         ###
//	 6	           #
//	 7	###      ###
//	 8	##      ###-
//	 9	#      ###--
//	10	##    ###---
//	11	########----
//	12	#######-----
//	13	-#####------
//	14	---##-------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr165[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x15,0x55,0x2a,0x01,0x55,0x02,0xa0,0x05,0xaa,0xaa,0x80,0xaa,0xaa,0xa8,0x02,0xaa,0x80,0x0a,0xaa,0x01,0x2a,0xa8,0x05,0x0a,0xa0,0x15,0x00,0x00,0x55,0x00,0x01,0x55,0x40,0x05,0x55,0x54,0x15,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	---------###
//	 3	--------#
//	 4	--------####
//	 5	--------###
//	 6	------##
//	 7	----##
//	 8	--##       #
//	 9	-#       ###
//	10	--     #####
//	11	-#    #####-
//	12	--#######---
//	13	--######----
//	14	---###------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr166[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x40,0x55,0x55,0x2a,0x55,0x55,0x00,0x55,0x55,0x02,0x55,0x50,0xaa,0x55,0x0a,0xaa,0x50,0xaa,0xa8,0x4a,0xaa,0x80,0x5a,0xa8,0x00,0x4a,0xa0,0x01,0x50,0x00,0x15,0x50,0x00,0x55,0x54,0x05,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	#######-----
//	 3	       #----
//	 4	       #----
//	 5	        #---
//	 6	   #     #--
//	 7	 ####    #--
//	 8	##########--
//	 9	##--#####---
//	10	#---#####---
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr167[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x01,0x55,0xaa,0xa8,0x55,0xaa,0xa8,0x55,0xaa,0xaa,0x15,0xa8,0xaa,0x85,0x80,0x2a,0x85,0x00,0x00,0x05,0x05,0x00,0x15,0x15,0x00,0x15,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	---------###
//	 3	-----###
//	 4	----#
//	 5	----#   ##
//	 6	----######
//	 7	-----####
//	 8	--------#
//	 9	--------#
//	10	--------#
//	11	--------#
//	12	--------#
//	13	--------##
//	14	---------###
//	15	---------###
//	16	----------##
//	17	------------
//		000000000011
//		012345678901
const char chr168[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x40,0x55,0x40,0xaa,0x55,0x2a,0xaa,0x55,0x2a,0x0a,0x55,0x00,0x0a,0x55,0x40,0x2a,0x55,0x55,0x2a,0x55,0x55,0x2a,0x55,0x55,0x2a,0x55,0x55,0x2a,0x55,0x55,0x2a,0x55,0x55,0x0a,0x55,0x55,0x40,0x55,0x55,0x40,0x55,0x55,0x50,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	####--------
//	 3	    ###-----
//	 4	       #----
//	 5	   ##  #----
//	 6	   #####----
//	 7	   #####----
//	 8	   #--------
//	 9	   #--------
//	10	   #--------
//	11	   #--------
//	12	   #--------
//	13	  ##--------
//	14	####--------
//	15	###---------
//	16	###---------
//	17	------------
//		000000000011
//		012345678901
const char chr169[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x55,0x55,0xaa,0x01,0x55,0xaa,0xa8,0x55,0xa8,0x28,0x55,0xa8,0x00,0x55,0xa8,0x00,0x55,0xa8,0x55,0x55,0xa8,0x55,0x55,0xa8,0x55,0x55,0xa8,0x55,0x55,0xa8,0x55,0x55,0xa0,0x55,0x55,0x00,0x55,0x55,0x01,0x55,0x55,0x01,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------######
//	 3	----#
//	 4	----#
//	 5	---#
//	 6	--#     ##
//	 7	--#    #####
//	 8	--##########
//	 9	---#####--##
//	10	---#####----
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr170[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x50,0x00,0x55,0x2a,0xaa,0x55,0x2a,0xaa,0x54,0xaa,0xaa,0x52,0xaa,0x0a,0x52,0xa8,0x00,0x50,0x00,0x00,0x54,0x00,0x50,0x54,0x00,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	###---------
//	 3	   #--------
//	 4	####--------
//	 5	  ##--------
//	 6	    ##------
//	 7	      ##----
//	 8	##       #--
//	 9	####      #-
//	10	#####      #
//	11	-######   #-
//	12	---########-
//	13	----######--
//	14	------###---
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr171[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x01,0x55,0x55,0xa8,0x55,0x55,0x00,0x55,0x55,0xa0,0x55,0x55,0xaa,0x05,0x55,0xaa,0xa0,0x55,0x0a,0xaa,0x85,0x00,0xaa,0xa1,0x00,0x2a,0xa8,0x40,0x02,0xa1,0x54,0x00,0x01,0x55,0x00,0x05,0x55,0x50,0x15,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	--------###-
//	 3	------##   #
//	 4	---##     ##
//	 5	-##
//	 6	#
//	 7	-#       ###
//	 8	-###      ##
//	 9	--###      #
//	10	---###     #
//	11	----########
//	12	-----#######
//	13	------#####-
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr172[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x01,0x55,0x50,0xa8,0x54,0x2a,0xa0,0x42,0xaa,0xaa,0x2a,0xaa,0xaa,0x4a,0xaa,0x80,0x40,0xaa,0xa0,0x50,0x2a,0xa8,0x54,0x0a,0xa8,0x55,0x00,0x00,0x55,0x40,0x00,0x55,0x50,0x01,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	#########---
//	 5	          ##
//	 6
//	 7	############
//	 8	###########-
//	 9	###########-
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr173[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x00,0x15,0xaa,0xaa,0xa0,0xaa,0xaa,0xaa,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x01,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	----#####--#
//	 5	---#    ##
//	 6	--#
//	 7	--#
//	 8	--#
//	 9	-#
//	10	-#
//	11	-####
//	12	-###########
//	13	--##########
//	14	---------###
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr174[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x14,0x54,0xaa,0x0a,0x52,0xaa,0xaa,0x52,0xaa,0xaa,0x52,0xaa,0xaa,0x4a,0xaa,0xaa,0x4a,0xaa,0xaa,0x40,0x2a,0xaa,0x40,0x00,0x00,0x50,0x00,0x00,0x55,0x55,0x40,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	----###-----
//	 3	-##    #----
//	 4	#      #----
//	 5	     ##-----
//	 6	  #####-----
//	 7	#####-------
//	 8	   ##-------
//	 9	     #------
//	10	     #------
//	11	     #------
//	12	######------
//	13	#####-------
//	14	####--------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr175[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x01,0x55,0x42,0xa8,0x55,0x2a,0xa8,0x55,0xaa,0x81,0x55,0xa0,0x01,0x55,0x00,0x15,0x55,0xa8,0x15,0x55,0xaa,0x85,0x55,0xaa,0x85,0x55,0xaa,0x85,0x55,0x00,0x05,0x55,0x00,0x15,0x55,0x00,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	-----------
//	 7	-----------
//	 8	---------- #
//	 9	---------- #
//	10	-----------
//	11	-----------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr176[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x56,0x55,0x55,0x56,0x55,0x55,0x58,0x55,0x55,0x58,0x55,0x55,0x56,0x55,0x55,0x56,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----  -----
//	 2	---  ##  ---
//	 3	-- ##  ## --
//	 4	- #      # -
//	 5	 #        #
//	 6	#          #
//	 7	#          #
//	 8	     ##
//	 9	     ##
//	10	#          #
//	11	#          #
//	12	 #        #
//	13	- #      # -
//	14	-- ##  ## --
//	15	---  ##  ---
//	16	-----  -----
//	17	------------
//		000000000011
//		012345678901
const char chr177[]  = {0x55,0x55,0x55,0x55,0x69,0x55,0x56,0x82,0x95,0x58,0x28,0x25,0x62,0xaa,0x89,0x8a,0xaa,0xa2,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0xaa,0x82,0xaa,0xaa,0x82,0xaa,0x2a,0xaa,0xa8,0x2a,0xaa,0xa8,0x8a,0xaa,0xa2,0x62,0xaa,0x89,0x58,0x28,0x25,0x56,0x82,0x95,0x55,0x69,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	 -----------
//	 7	 -----------
//	 8	# ----------
//	 9	# ----------
//	10	 -----------
//	11	 -----------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr178[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x95,0x55,0x55,0x95,0x55,0x55,0x25,0x55,0x55,0x25,0x55,0x55,0x95,0x55,0x55,0x95,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	 ----------
//	 7	 ----------
//	 8	# -------- #
//	 9	# -------- #
//	10	 ----------
//	11	 ----------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr179[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x95,0x55,0x56,0x95,0x55,0x56,0x25,0x55,0x58,0x25,0x55,0x58,0x95,0x55,0x56,0x95,0x55,0x56,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	---------- -
//	 1	--------- --
//	 2	--------#---
//	 3	-----##-#---
//	 4	----#####---
//	 5	---######---
//	 6	--########--
//	 7	-##########-
//	 8	##        ##
//	 9	-#    ### #-
//	10	-#    #-# #-
//	11	-#    ### #-
//	12	-#        #-
//	13	-#        #-
//	14	-# ###    #-
//	15	-# #-#    #-
//	16	-# #-#    #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr180[]  = {0x55,0x55,0x59,0x55,0x55,0x65,0x55,0x55,0x15,0x55,0x41,0x15,0x55,0x00,0x15,0x54,0x00,0x15,0x50,0x00,0x05,0x40,0x00,0x01,0x0a,0xaa,0xa0,0x4a,0xa0,0x21,0x4a,0xa1,0x21,0x4a,0xa0,0x21,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x48,0x0a,0xa1,0x48,0x4a,0xa1,0x48,0x4a,0xa1,0x40,0x00,0x01};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	----    ----
//	 5	---- ## ----
//	 6	---- ## ----
//	 7	---- ## ----
//	 8	     ##
//	 9	 ##########
//	10	 #        #
//	11	 # ##  ## #
//	12	 # ##  ## #
//	13	 #        #
//	14	 #        #
//	15	 ##########
//	16
//	17	------------
//		000000000011
//		012345678901
const char chr181[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0xaa,0x55,0x55,0x82,0x55,0x55,0x82,0x55,0x55,0x82,0x55,0xaa,0x82,0xaa,0x80,0x00,0x02,0x8a,0xaa,0xa2,0x88,0x28,0x22,0x88,0x28,0x22,0x8a,0xaa,0xa2,0x8a,0xaa,0xa2,0x80,0x00,0x02,0xaa,0xaa,0xaa,0x55,0x55,0x55};


//	 0	------##----
//	 1	-----#  #---
//	 2	----#    #--
//	 3	----#     #-
//	 4	-----#     #
//	 5	------#    #
//	 6	-------#
//	 7	--------## -
//	 8	----------#
//	 9	--------#-
//	10	------#- --
//	11	----#- # #--
//	12	---# # ##  #
//	13	---# ## ##--
//	14	----# ##  #-
//	15	-----# ##---
//	16	------#  #--
//	17	-------##---
//		000000000011
//		012345678901
const char chr182[]  = {0x55,0x50,0x55,0x55,0x4a,0x15,0x55,0x2a,0x85,0x55,0x2a,0xa1,0x55,0x4a,0xa8,0x55,0x52,0xa8,0x55,0x54,0xaa,0x55,0x55,0x09,0x55,0x55,0x52,0x55,0x55,0x1a,0x55,0x51,0x96,0x55,0x18,0x85,0x54,0x88,0x28,0x54,0x82,0x05,0x55,0x20,0xa1,0x55,0x48,0x15,0x55,0x52,0x85,0x55,0x54,0x15};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	-#----------
//	 6	# #---------
//	 7	   #--------
//	 8	  #---------
//	 9	 - ##-------
//	10	#    #------
//	11	-#    #-----
//	12	-#     #----
//	13	--#     #---
//	14	---#    #---
//	15	----#  #----
//	16	-----##-----
//	17	------------
//		000000000011
//		012345678901
const char chr183[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x45,0x55,0x55,0x21,0x55,0x55,0xa8,0x55,0x55,0xa1,0x55,0x55,0x98,0x15,0x55,0x2a,0x85,0x55,0x4a,0xa1,0x55,0x4a,0xa8,0x55,0x52,0xaa,0x15,0x54,0xaa,0x15,0x55,0x28,0x55,0x55,0x41,0x55,0x55,0x55,0x55};


//	 0	---#     #--
//	 1	--# ##### #-
//	 2	-# ##   ## #
//	 3	- ## ### ##
//	 4	- # ## ## #
//	 5	- # #   # #
//	 6	- # ## ## #
//	 7	- ## # # ##
//	 8	-# ### ### #
//	 9	--# ## ## #-
//	10	---#-# #-#--
//	11	-----# #----
//	12	-----# #----
//	13	-----# #----
//	14	-----# #----
//	15	-----# #----
//	16	----#   #---
//	17	---#     #--
//		000000000011
//		012345678901
const char chr184[] = {0x52,0xaa,0x15,0x48,0x00,0x85,0x20,0xa8,0x21,0x82,0x02,0x09,0x88,0x20,0x89,0x88,0xa8,0x89,0x88,0x20,0x89,0x82,0x22,0x09,0x20,0x20,0x21,0x48,0x20,0x85,0x51,0x21,0x15,0x55,0x21,0x55,0x55,0x21,0x55,0x55,0x21,0x55,0x55,0x21,0x55,0x55,0x21,0x55,0x54,0xa8,0x55,0x52,0xaa,0x15};

//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	# # # # ####
//	 7	 ------#   #
//	 8	#-------#  #
//	 9	 ------# # #
//	10	#-----# #-#
//	11	 ----# #---#
//	12	#---# #----
//	13	 #-# #-----#
//	14	# # #------
//	15	#  #-------#
//	16	#   #------
//	17	#### # # # #
//		000000000011
//		012345678901
const char chr185[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x22,0x22,0x00,0x95,0x54,0xa8,0x15,0x55,0x28,0x95,0x54,0x88,0x15,0x52,0x12,0x95,0x48,0x54,0x15,0x21,0x56,0x84,0x85,0x54,0x22,0x15,0x56,0x28,0x55,0x54,0x2a,0x15,0x56,0x00,0x88,0x88};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	--##----##--
//	 4	-#  #--#  #-
//	 5	-#   #-#  #-
//	 6	-#   ###  #-
//	 7	-#    ##  #-
//	 8	##  #  #  ##
//	 9	 #  #  #  #
//	10	##  ##    ##
//	11	-#  ###   #-
//	12	-#  #-#   #-
//	13	-#  #--#  #-
//	14	--##----##--
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr186[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x50,0x55,0x05,0x4a,0x14,0xa1,0x4a,0x84,0xa1,0x4a,0x80,0xa1,0x4a,0xa0,0xa1,0x0a,0x28,0xa0,0x8a,0x28,0xa2,0x0a,0x0a,0xa0,0x4a,0x02,0xa1,0x4a,0x12,0xa1,0x4a,0x14,0xa1,0x50,0x55,0x05,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	----####----
//	 4	---#    #---
//	 5	--#      #--
//	 6	--#  ### #--
//	 7	--#  #------
//	 8	###     ####
//	 9	   #     #
//	10	#######  ###
//	11	--# ###  #--
//	12	--#      #--
//	13	--##    ##--
//	14	----#####---
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr187[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x55,0x54,0xaa,0x15,0x52,0xaa,0x85,0x52,0x80,0x85,0x52,0x85,0x55,0x02,0xaa,0x00,0xa8,0xaa,0x8a,0x00,0x02,0x80,0x52,0x02,0x85,0x52,0xaa,0x85,0x50,0xaa,0x05,0x55,0x00,0x15,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	---######---
//	 4	--#      #--
//	 5	--#      #--
//	 6	--#  ####---
//	 7	--#  #------
//	 8	###    #####
//	 9	  #    #
//	10	###  #######
//	11	--#  ###----
//	12	--#      #--
//	13	--#      #--
//	14	---######---
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr188[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x54,0x00,0x15,0x52,0xaa,0x85,0x52,0xaa,0x85,0x52,0x80,0x15,0x52,0x85,0x55,0x02,0xa8,0x00,0xa2,0xa8,0xaa,0x02,0x80,0x00,0x52,0x80,0x55,0x52,0xaa,0x85,0x52,0xaa,0x85,0x54,0x00,0x15,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	--##----##--
//	 4	-#  #--#  #-
//	 5	-#  #--#  #-
//	 6	-#  #--#  #-
//	 7	-#  ####  #-
//	 8	##  #  #  ##
//	 9	  # #  # #
//	10	### #  # ###
//	11	--#  ##  #--
//	12	--#  ##  #--
//	13	--#  ##  #--
//	14	---######---
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr189[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x50,0x55,0x05,0x4a,0x14,0xa1,0x4a,0x14,0xa1,0x4a,0x14,0xa1,0x4a,0x00,0xa1,0x0a,0x28,0xa0,0xa2,0x28,0x8a,0x02,0x28,0x80,0x52,0x82,0x85,0x52,0x82,0x85,0x52,0x82,0x85,0x54,0x00,0x15,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	-----#------
//	 7	----# #-----
//	 8	###-# #-####
//	 9	   ## ##
//	10	###-# #-####
//	11	----# #-----
//	12	-----#------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr190[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x45,0x55,0x55,0x21,0x55,0x01,0x21,0x00,0xa8,0x20,0xaa,0x01,0x21,0x00,0x55,0x21,0x55,0x55,0x45,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	------------
//	 8	############
//	 9
//	10	############
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr191[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x00,0x00,0xaa,0xaa,0xaa,0x00,0x00,0x00,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	----------##
//	 7	-------###
//	 8	-----##
//	 9	----#
//	10	---#
//	11	--#       ##
//	12	--#      #--
//	13	-#      #---
//	14	-#     #----
//	15	-#     #----
//	16	-#     #----
//	17	-#     #----
//		000000000011
//		012345678901
const char chr192[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x50,0x55,0x54,0x0a,0x55,0x42,0xaa,0x55,0x2a,0xaa,0x54,0xaa,0xaa,0x52,0xaa,0xa0,0x52,0xaa,0x85,0x4a,0xaa,0x15,0x4a,0xa8,0x55,0x4a,0xa8,0x55,0x4a,0xa8,0x55,0x4a,0xa8,0x55};


//	 0	------------
//	 1	------------
//	 2	-----------#
//	 3	-----------#
//	 4	-----------#
//	 5	-----------#
//	 6	####-------#
//	 7	    #####--#
//	 8	        #--#
//	 9	        #--#
//	10	        #--#
//	11	###     #--#
//	12	--#     #--#
//	13	--#     #--#
//	14	--#     #--#
//	15	--#     #--#
//	16	--#     #--#
//	17	--#     #--#
//		000000000011
//		012345678901
const char chr193[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x54,0x55,0x55,0x54,0x55,0x55,0x54,0x55,0x55,0x54,0x00,0x55,0x54,0xaa,0x00,0x14,0xaa,0xaa,0x14,0xaa,0xaa,0x14,0xaa,0xaa,0x14,0x02,0xaa,0x14,0x52,0xaa,0x14,0x52,0xaa,0x14,0x52,0xaa,0x14,0x52,0xaa,0x14,0x52,0xaa,0x14,0x52,0xaa,0x14};


//	 0	------------
//	 1	######------
//	 2	#     #-----
//	 3	      #-----
//	 4	      #-----
//	 5	      #-----
//	 6	      #-----
//	 7	     #--####
//	 8	     #--#
//	 9	     #--#
//	10	     #--#
//	11	     #--#
//	12	     #--#
//	13	     #--#
//	14	     #--#
//	15	     #--#
//	16	     #--#
//	17	     #--#
//		000000000011
//		012345678901
const char chr194[]  = {0x55,0x55,0x55,0x00,0x05,0x55,0x2a,0xa1,0x55,0xaa,0xa1,0x55,0xaa,0xa1,0x55,0xaa,0xa1,0x55,0xaa,0xa1,0x55,0xaa,0x85,0x00,0xaa,0x85,0x2a,0xaa,0x85,0x2a,0xaa,0x85,0x2a,0xaa,0x85,0x2a,0xaa,0x85,0x2a,0xaa,0x85,0x2a,0xaa,0x85,0x2a,0xaa,0x85,0x2a,0xaa,0x85,0x2a,0xaa,0x85,0x2a};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	###------###
//	 8	  #------#
//	 9	  #------#
//	10	  #------#
//	11	  #-----#
//	12	  #-----#
//	13	  #-----#
//	14	  #-----#
//	15	  #-----#
//	16	  #-----#
//	17	  #-----#
//		000000000011
//		012345678901
const char chr195[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x01,0x55,0x40,0xa1,0x55,0x4a,0xa1,0x55,0x4a,0xa1,0x55,0x4a,0xa1,0x55,0x2a,0xa1,0x55,0x2a,0xa1,0x55,0x2a,0xa1,0x55,0x2a,0xa1,0x55,0x2a,0xa1,0x55,0x2a,0xa1,0x55,0x2a};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	--------####
//	 7	########
//	 8	   #
//	 9	   #
//	10
//	11	        ####
//	12	      ##---#
//	13	      #-----
//	14	     ##-----
//	15	     #------
//	16	     #------
//	17	     #------
//		000000000011
//		012345678901
const char chr196[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x00,0x00,0xaa,0xa8,0xaa,0xaa,0xa8,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0x00,0xaa,0xa0,0x54,0xaa,0xa1,0x55,0xaa,0x81,0x55,0xaa,0x85,0x55,0xaa,0x85,0x55,0xaa,0x85,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	###------###
//	 8	   ##----#
//	 9	    ##---#
//	10	     ##--#
//	11	      #--#
//	12	#     #--#
//	13	#      #-#
//	14	-#     #-#
//	15	-#     #-#
//	16	-#     #-#
//	17	-#     #-#
//		000000000011
//		012345678901
const char chr197[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x01,0x55,0x40,0xa8,0x15,0x4a,0xaa,0x05,0x4a,0xaa,0x81,0x4a,0xaa,0xa1,0x4a,0x2a,0xa1,0x4a,0x2a,0xa8,0x4a,0x4a,0xa8,0x4a,0x4a,0xa8,0x4a,0x4a,0xa8,0x4a,0x4a,0xa8,0x4a};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	-------####-
//	 7	#######    #
//	 8	   #
//	 9
//	10
//	11
//	12	     #####
//	13	    #----##
//	14	   ##-----#
//	15	   #------#
//	16	   #------#
//	17	   #------#
//		000000000011
//		012345678901
const char chr198[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x54,0x01,0x00,0x02,0xa8,0xa8,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0x80,0x0a,0xaa,0x15,0x42,0xa8,0x15,0x52,0xa8,0x55,0x52,0xa8,0x55,0x52,0xa8,0x55,0x52};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	##-----#####
//	 8	  ##---#
//	 9	   #---#
//	10	    #--#
//	11	    #--#
//	12	    #--#
//	13	    #--#
//	14	    #--#
//	15	    #--#
//	16	    #-#
//	17	    #-#
//		000000000011
//		012345678901
const char chr199[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x05,0x54,0x00,0xa0,0x54,0xaa,0xa8,0x54,0xaa,0xaa,0x14,0xaa,0xaa,0x14,0xaa,0xaa,0x14,0xaa,0xaa,0x14,0xaa,0xaa,0x14,0xaa,0xaa,0x14,0xaa,0xaa,0x12,0xaa,0xaa,0x12,0xaa};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	-######-----
//	 7	#      ###--
//	 8	          ##
//	 9	           #
//	10
//	11	 #####
//	12	 #----#
//	13	 #-----#
//	14	##-----#
//	15	#-------#
//	16	#-------#
//	17	#------#
//		000000000011
//		012345678901
const char chr200[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x40,0x01,0x55,0x2a,0xa8,0x05,0xaa,0xaa,0xa0,0xaa,0xaa,0xa8,0xaa,0xaa,0xaa,0x80,0x0a,0xaa,0x85,0x52,0xaa,0x85,0x54,0xaa,0x05,0x54,0xaa,0x15,0x55,0x2a,0x15,0x55,0x2a,0x15,0x54,0xaa};


//	 0	------------
//	 1	----#######-
//	 2	----#     #-
//	 3	----#     #-
//	 4	----#     #-
//	 5	----#######-
//	 6	------------
//	 7	----#######-
//	 8	----#     #-
//	 9	#---#     #-
//	10	#---#     #-
//	11	 #--#     #-
//	12	 #--#     #-
//	13	 #--#     #-
//	14	  #-#     #-
//	15	  #-#     #-
//	16	  #-#     #-
//	17	  #-#     #-
//		000000000011
//		012345678901
const char chr201[]  = {0x55,0x55,0x55,0x55,0x00,0x01,0x55,0x2a,0xa1,0x55,0x2a,0xa1,0x55,0x2a,0xa1,0x55,0x00,0x01,0x55,0x55,0x55,0x55,0x00,0x01,0x55,0x2a,0xa1,0x15,0x2a,0xa1,0x15,0x2a,0xa1,0x85,0x2a,0xa1,0x85,0x2a,0xa1,0x85,0x2a,0xa1,0xa1,0x2a,0xa1,0xa1,0x2a,0xa1,0xa1,0x2a,0xa1,0xa1,0x2a,0xa1};


//	 0	------------
//	 1	--######----
//	 2	-##    #----
//	 3	-#     #----
//	 4	-#     #----
//	 5	-#     #----
//	 6	-#     #----
//	 7	-#     #----
//	 8	-#     #----
//	 9	-#     #---#
//	10	-#     #--##
//	11	-#     #--#
//	12	-#     #-#
//	13	-#     #-#
//	14	-#     #-#
//	15	-#     #-#
//	16	-#     #-#
//	17	-#     #-#
//		000000000011
//		012345678901
const char chr202[]  = {0x55,0x55,0x55,0x50,0x00,0x55,0x42,0xa8,0x55,0x4a,0xa8,0x55,0x4a,0xa8,0x55,0x4a,0xa8,0x55,0x4a,0xa8,0x55,0x4a,0xa8,0x55,0x4a,0xa8,0x55,0x4a,0xa8,0x54,0x4a,0xa8,0x50,0x4a,0xa8,0x52,0x4a,0xa8,0x4a,0x4a,0xa8,0x4a,0x4a,0xa8,0x4a,0x4a,0xa8,0x4a,0x4a,0xa8,0x4a,0x4a,0xa8,0x4a};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	-----####---
//	 7	--###    ###
//	 8	##
//	 9	#
//	10
//	11	     ####
//	12	    ##---#
//	13	   ##-----#
//	14	   #------#
//	15	   #------#
//	16	   #------#
//	17	   #------#
//		000000000011
//		012345678901
const char chr203[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x40,0x15,0x50,0x2a,0x80,0x0a,0xaa,0xaa,0x2a,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0x80,0x2a,0xaa,0x05,0x4a,0xa8,0x15,0x52,0xa8,0x55,0x52,0xa8,0x55,0x52,0xa8,0x55,0x52,0xa8,0x55,0x52};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	---------###
//	 4	--------##
//	 5	--------#
//	 6	--------#
//	 7	#-----###
//	 8	##---#
//	 9	  #--#
//	10	   #-#
//	11	    ###
//	12	    #--##
//	13	    #---#
//	14	     #--#
//	15	     #-#
//	16	     #-#
//	17	    ##-#
//		000000000011
//		012345678901
const char chr204[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x40,0x55,0x55,0x0a,0x55,0x55,0x2a,0x55,0x55,0x2a,0x15,0x50,0x2a,0x05,0x4a,0xaa,0xa1,0x4a,0xaa,0xa8,0x4a,0xaa,0xaa,0x02,0xaa,0xaa,0x14,0x2a,0xaa,0x15,0x2a,0xaa,0x85,0x2a,0xaa,0x84,0xaa,0xaa,0x84,0xaa,0xaa,0x04,0xaa};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	###---------
//	 4	  #---------
//	 5	  #---------
//	 6	  #---------
//	 7	  #####-----
//	 8	      #-----
//	 9	      #-----
//	10	      #-----
//	11	     ##-----
//	12	  ####------
//	13	  #---------
//	14	  #---------
//	15	  #---------
//	16	  #---------
//	17	 #----------
//		000000000011
//		012345678901
const char chr205[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x01,0x55,0x55,0xa1,0x55,0x55,0xa1,0x55,0x55,0xa1,0x55,0x55,0xa0,0x01,0x55,0xaa,0xa1,0x55,0xaa,0xa1,0x55,0xaa,0xa1,0x55,0xaa,0x81,0x55,0xa0,0x05,0x55,0xa1,0x55,0x55,0xa1,0x55,0x55,0xa1,0x55,0x55,0xa1,0x55,0x55,0x85,0x55,0x55};


//	 0	---------
//	 1	--        ##
//	 2	-- #########
//	 3	-  #########
//	 4	- ##########
//	 5	- ##########
//	 6	-          #
//	 7	----------
//	 8	-----------
//	 9	----------
//	10	---------- #
//	11	---------  #
//	12	--------  ##
//	13	-------  ###
//	14	------  ####
//	15	-----  #####
//	16	----  ######
//	17	---  #######
//		000000000011
//		012345678901
const char chr206[]  = {0x55,0x55,0x6a,0x5a,0xaa,0xa0,0x58,0x00,0x00,0x68,0x00,0x00,0x60,0x00,0x00,0x60,0x00,0x00,0x6a,0xaa,0xa8,0x55,0x55,0x5a,0x55,0x55,0x56,0x55,0x55,0x5a,0x55,0x55,0x58,0x55,0x55,0x68,0x55,0x55,0xa0,0x55,0x56,0x80,0x55,0x5a,0x00,0x55,0x68,0x00,0x55,0xa0,0x00,0x56,0x80,0x00};


//	 0	  ----------
//	 1	#     ------
//	 2	#####   ----
//	 3	#######  ---
//	 4	######## ---
//	 5	######## ---
//	 6	######## ---
//	 7	######## ---
//	 8	######## ---
//	 9	######## ---
//	10	#######  ---
//	11	####### ----
//	12	######  ----
//	13	#####  -----
//	14	####  ------
//	15	###  -------
//	16	##  --------
//	17	#  ---------
//		000000000011
//		012345678901
const char chr207[]  = {0xa5,0x55,0x55,0x2a,0xa5,0x55,0x00,0x2a,0x55,0x00,0x02,0x95,0x00,0x00,0x95,0x00,0x00,0x95,0x00,0x00,0x95,0x00,0x00,0x95,0x00,0x00,0x95,0x00,0x00,0x95,0x00,0x02,0x95,0x00,0x02,0x55,0x00,0x0a,0x55,0x00,0x29,0x55,0x00,0xa5,0x55,0x02,0x95,0x55,0x0a,0x55,0x55,0x29,0x55,0x55};


//	 0	-#     #----
//	 1	-#     #----
//	 2	-#      ####
//	 3	-#
//	 4	--#
//	 5	---#
//	 6	----##
//	 7	------######
//	 8	------------
//	 9	--####------
//	10	--#   ######
//	11	--#
//	12	--#
//	13	--##
//	14	---####
//	15	-------#####
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr208[]  = {0x4a,0xa8,0x55,0x4a,0xa8,0x55,0x4a,0xaa,0x00,0x4a,0xaa,0xaa,0x52,0xaa,0xaa,0x54,0xaa,0xaa,0x55,0x0a,0xaa,0x55,0x50,0x00,0x55,0x55,0x55,0x50,0x05,0x55,0x52,0xa0,0x00,0x52,0xaa,0xaa,0x52,0xaa,0xaa,0x50,0xaa,0xaa,0x54,0x02,0xaa,0x55,0x54,0x00,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	-#      #--#
//	 1	-#      #--#
//	 2	#       #--#
//	 3	        #--#
//	 4	        #--#
//	 5	  #     #--#
//	 6	###     #--#
//	 7	-##     #--#
//	 8	-#      #---
//	 9	##      #---
//	10	#      #----
//	11	       #----
//	12	      #-----
//	13	     ##-----
//	14	  ###-------
//	15	##----------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr209[]  = {0x4a,0xaa,0x14,0x4a,0xaa,0x14,0x2a,0xaa,0x14,0xaa,0xaa,0x14,0xaa,0xaa,0x14,0xa2,0xaa,0x14,0x02,0xaa,0x14,0x42,0xaa,0x14,0x4a,0xaa,0x15,0x0a,0xaa,0x15,0x2a,0xa8,0x55,0xaa,0xa8,0x55,0xaa,0xa1,0x55,0xaa,0x81,0x55,0xa0,0x15,0x55,0x05,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	     #--#
//	 1	     #--#
//	 2	     #--#
//	 3	     #--#
//	 4	     #--#
//	 5	     #---#
//	 6	     #---##
//	 7	#####------#
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr210[]  = {0xaa,0x85,0x2a,0xaa,0x85,0x2a,0xaa,0x85,0x2a,0xaa,0x85,0x2a,0xaa,0x85,0x2a,0xaa,0x85,0x4a,0xaa,0x85,0x42,0x00,0x15,0x54,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	  #-----#
//	 1	  #----#
//	 2	   ####
//	 3
//	 4
//	 5
//	 6	       ##
//	 7	#######--###
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr211[]  = {0xa1,0x55,0x2a,0xa1,0x54,0xaa,0xa8,0x02,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xa8,0x2a,0x00,0x01,0x40,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	     #------
//	 1	      #-----
//	 2	       ##-##
//	 3	         #
//	 4
//	 5	  #
//	 6	  ###
//	 7	##---#######
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr212[]  = {0xaa,0x85,0x55,0xaa,0xa1,0x55,0xaa,0xa8,0x10,0xaa,0xaa,0x8a,0xaa,0xaa,0xaa,0xa2,0xaa,0xaa,0xa0,0x2a,0xaa,0x05,0x40,0x00,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	#      #-#
//	 1	#     #--#
//	 2	      #--#
//	 3	     ##-##
//	 4	     #--#
//	 5	   ##---#
//	 6	  ##----#
//	 7	##-------###
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr213[]  = {0x2a,0xa8,0x4a,0x2a,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0x81,0x0a,0xaa,0x85,0x2a,0xa8,0x15,0x2a,0xa0,0x55,0x2a,0x05,0x55,0x40,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	   #------#
//	 1	   #------#
//	 2	   #------#
//	 3	   #-----##
//	 4	   #-----#
//	 5	   #-----#
//	 6	  ##-----#
//	 7	###-------##
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr214[]  = {0xa8,0x55,0x52,0xa8,0x55,0x52,0xa8,0x55,0x52,0xa8,0x55,0x42,0xa8,0x55,0x4a,0xa8,0x55,0x4a,0xa0,0x55,0x4a,0x01,0x55,0x50,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	    #-#
//	 1	    #-#
//	 2	    #-#
//	 3	    #-#
//	 4	    #-#
//	 5	    #-#
//	 6	   #--#
//	 7	####--#
//	 8	------#
//	 9	------#
//	10	------#
//	11	------#
//	12	------#
//	13	------#
//	14	------######
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr215[]  = {0xaa,0x12,0xaa,0xaa,0x12,0xaa,0xaa,0x12,0xaa,0xaa,0x12,0xaa,0xaa,0x12,0xaa,0xaa,0x12,0xaa,0xa8,0x52,0xaa,0x00,0x52,0xaa,0x55,0x52,0xaa,0x55,0x52,0xaa,0x55,0x52,0xaa,0x55,0x52,0xaa,0x55,0x52,0xaa,0x55,0x52,0xaa,0x55,0x50,0x00,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	 #-----#
//	 1	 #----##
//	 2	  ##-##
//	 3	    #
//	 4
//	 5	#          #
//	 6	##       ##-
//	 7	#-########--
//	 8	#-----------
//	 9	#-----------
//	10	#-----------
//	11	#-----------
//	12	#-----------
//	13	#-----------
//	14	#-----------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr216[]  = {0x85,0x54,0xaa,0x85,0x50,0xaa,0xa0,0x42,0xaa,0xaa,0x2a,0xaa,0xaa,0xaa,0xaa,0x2a,0xaa,0xa8,0x0a,0xaa,0x81,0x10,0x00,0x05,0x15,0x55,0x55,0x15,0x55,0x55,0x15,0x55,0x55,0x15,0x55,0x55,0x15,0x55,0x55,0x15,0x55,0x55,0x15,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	 #--#     #-
//	 1	 #--#     #-
//	 2	 #-#      #-
//	 3	##-#      #-
//	 4	#--#      #-
//	 5	---#      #-
//	 6	---#     ##-
//	 7	----######--
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr217[]  = {0x85,0x2a,0xa1,0x85,0x2a,0xa1,0x84,0xaa,0xa1,0x04,0xaa,0xa1,0x14,0xaa,0xa1,0x54,0xaa,0xa1,0x54,0xaa,0x81,0x55,0x00,0x05,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	##     #-#
//	 1	#      #-#
//	 2	#      #-#
//	 3	#      #--#
//	 4	#      #--##
//	 5	#      #---#
//	 6	#     ##----
//	 7	-######-----
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr218[]  = {0x0a,0xa8,0x4a,0x2a,0xa8,0x4a,0x2a,0xa8,0x4a,0x2a,0xa8,0x52,0x2a,0xa8,0x50,0x2a,0xa8,0x54,0x2a,0xa0,0x55,0x40,0x01,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	   #------#
//	 1	   ##----##
//	 2	    ##--##
//	 3	      ##
//	 4
//	 5	#
//	 6	###        #
//	 7	--##########
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr219[]  = {0xa8,0x55,0x52,0xa8,0x15,0x42,0xaa,0x05,0x0a,0xaa,0xa0,0xaa,0xaa,0xaa,0xaa,0x2a,0xaa,0xaa,0x02,0xaa,0xa8,0x50,0x00,0x00,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	    #--#
//	 1	    #--#
//	 2	    #--#
//	 3	   #---#
//	 4	  ##---#
//	 5	 ##-----#
//	 6	#-------##
//	 7	---------###
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr220[]  = {0xaa,0x14,0xaa,0xaa,0x14,0xaa,0xaa,0x14,0xaa,0xa8,0x54,0xaa,0xa0,0x54,0xaa,0x81,0x55,0x2a,0x15,0x55,0x0a,0x55,0x55,0x40,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	 #----------
//	 1	 #----------
//	 2	  #-##-----
//	 3	   #  #----
//	 4	      #----
//	 5	     #-----
//	 6	     #-----
//	 7	######-----
//	 8	-----------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr221[]  = {0x85,0x55,0x55,0x85,0x55,0x55,0xa1,0x05,0x56,0xa8,0xa1,0x56,0xaa,0xa1,0x56,0xaa,0x85,0x56,0xaa,0x85,0x56,0x00,0x05,0x56,0x55,0x55,0x56,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	--  ########
//	 1	   ########
//	 2	 #########
//	 3	############
//	 4	############
//	 5	############
//	 6	############
//	 7	############
//	 8
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr222[]  = {0x5a,0x00,0x00,0xa8,0x00,0x02,0x80,0x00,0x0a,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xaa,0xaa,0xaa,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	  ----------
//	 1	 -----------
//	 2	        ----
//	 3	####### ----
//	 4	####### ----
//	 5	####### ----
//	 6	####### ----
//	 7	####### ----
//	 8	        ----
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr223[]  = {0xa5,0x55,0x55,0x95,0x55,0x55,0xaa,0xaa,0x55,0x00,0x02,0x55,0x00,0x02,0x55,0x00,0x02,0x55,0x00,0x02,0x55,0x00,0x02,0x55,0xaa,0xaa,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	------------
//	 8	------------
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr224[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	--##----##--
//	 4	-#  #--#  #-
//	 5	# ## ## ###-
//	 6	# ## ## ###-
//	 7	# ## ### #--
//	 8	# ## #### #-
//	 9	# ## #### #-
//	10	##  ###  ##-
//	11	-####-####--
//	12	--##---##---
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr225[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x50,0x55,0x05,0x4a,0x14,0xa1,0x20,0x82,0x01,0x20,0x82,0x01,0x20,0x80,0x85,0x20,0x80,0x21,0x20,0x80,0x21,0x0a,0x02,0x81,0x40,0x10,0x05,0x50,0x54,0x15,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	--------#---
//	 1	-------# #--
//	 2	-#########--
//	 3	-#    ## #--
//	 4	-# # # # #--
//	 5	-# # # # #--
//	 6	-# # # # #--
//	 7	-#########--
//	 8	-########---
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr226[]  = {0x55,0x55,0x15,0x55,0x54,0x85,0x40,0x00,0x05,0x4a,0xa0,0x85,0x48,0x88,0x85,0x48,0x88,0x85,0x48,0x88,0x85,0x40,0x00,0x05,0x40,0x00,0x15,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	--#---------
//	 1	-# #--------
//	 2	-# ##-####--
//	 3	-# # #    #-
//	 4	-#  ## # # #
//	 5	-#  ## # # #
//	 6	-# # # # # #
//	 7	-###########
//	 8	--#########-
//	 9	------------
//	10	------------
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr227[]  = {0x51,0x55,0x55,0x48,0x55,0x55,0x48,0x10,0x05,0x48,0x8a,0xa1,0x4a,0x08,0x88,0x4a,0x08,0x88,0x48,0x88,0x88,0x40,0x00,0x00,0x50,0x00,0x01,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-#   ##   #-
//	 4	-#        #-
//	 5	-#        #-
//	 6	-#    ##  #-
//	 7	-#   ###  #-
//	 8	-#  ####  #-
//	 9	-#  ####  #-
//	10	-#    ##  #-
//	11	-#    ##  #-
//	12	-#    ##  #-
//	13	-#    ##  #-
//	14	-#   #### #-
//	15	-#   #### #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr228[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x4a,0x82,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0xa0,0xa1,0x4a,0x80,0xa1,0x4a,0x00,0xa1,0x4a,0x00,0xa1,0x4a,0xa0,0xa1,0x4a,0xa0,0xa1,0x4a,0xa0,0xa1,0x4a,0xa0,0xa1,0x4a,0x80,0x21,0x4a,0x80,0x21,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-#   ##   #-
//	 4	-#        #-
//	 5	-#        #-
//	 6	-#  ####  #-
//	 7	-# ###### #-
//	 8	-# ##  ## #-
//	 9	-# ##  ## #-
//	10	-#    ### #-
//	11	-#   ###  #-
//	12	-#  ###   #-
//	13	-# ###    #-
//	14	-# ###### #-
//	15	-# ###### #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr229[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x4a,0x82,0xa1,0x4a,0xaa,0xa1,0x4a,0xaa,0xa1,0x4a,0x00,0xa1,0x48,0x00,0x21,0x48,0x28,0x21,0x48,0x28,0x21,0x4a,0xa0,0x21,0x4a,0x80,0xa1,0x4a,0x02,0xa1,0x48,0x0a,0xa1,0x48,0x00,0x21,0x48,0x00,0x21,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	---##--#--#-
//	 1	--#  ## ## #
//	 2	-# ## #  # #
//	 3	-# ## # #  #
//	 4	-# ## # #  #
//	 5	-##  ## ## #
//	 6	--##########
//	 7	---#####--#-
//	 8	----#   #---
//	 9	---# # # #--
//	10	--# ## ## #-
//	11	-# #-# ### #
//	12	-# #-#   # #
//	13	-# #--#### #
//	14	-## #---# ##
//	15	--## ### ##-
//	16	---##   ##--
//	17	----#####---
//		000000000011
//		012345678901
const char chr230[]  = {0x54,0x14,0x51,0x52,0x82,0x08,0x48,0x22,0x88,0x48,0x22,0x28,0x48,0x22,0x28,0x42,0x82,0x08,0x50,0x00,0x00,0x54,0x00,0x51,0x55,0x2a,0x15,0x54,0x88,0x85,0x52,0x08,0x21,0x48,0x48,0x08,0x48,0x4a,0x88,0x48,0x50,0x08,0x42,0x15,0x20,0x50,0x80,0x81,0x54,0x2a,0x05,0x55,0x00,0x15};


//	 0	-###-#--#-#-
//	 1	#   # ## # #
//	 2	# ### ## # #
//	 3	#  ## #-# ##
//	 4	# ### ### #-
//	 5	# #-#   # #-
//	 6	###-#######-
//	 7	-#---###-#--
//	 8	----#   #---
//	 9	---# # # #--
//	10	--# ## ## #-
//	11	-# #-# ### #
//	12	-# #-#   # #
//	13	-# #--#### #
//	14	-## #---# ##
//	15	--## ### ##-
//	16	---##   ##--
//	17	----#####---
//		000000000011
//		012345678901
const char chr231[]  = {0x40,0x45,0x11,0x2a,0x20,0x88,0x20,0x20,0x88,0x28,0x21,0x20,0x20,0x20,0x21,0x21,0x2a,0x21,0x01,0x00,0x01,0x45,0x40,0x45,0x55,0x2a,0x15,0x54,0x88,0x85,0x52,0x08,0x21,0x48,0x48,0x08,0x48,0x4a,0x88,0x48,0x50,0x08,0x42,0x15,0x20,0x50,0x80,0x81,0x54,0x2a,0x05,0x55,0x00,0x15};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-# ###### #-
//	 4	-# ###### #-
//	 5	-# ###### #-
//	 6	-# ##  ## #-
//	 7	-# #    # #-
//	 8	-# # ## # #-
//	 9	-# #### # #-
//	10	-# ###  # #-
//	11	-# ##  ## #-
//	12	-# #  ### #-
//	13	-# #    # #-
//	14	-# #    # #-
//	15	-# ###### #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr232[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x28,0x21,0x48,0xaa,0x21,0x48,0x82,0x21,0x48,0x02,0x21,0x48,0x0a,0x21,0x48,0x28,0x21,0x48,0xa0,0x21,0x48,0xaa,0x21,0x48,0xaa,0x21,0x48,0x00,0x21,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	##       ##-
//	 1	##       ##-
//	 2	##       ##-
//	 3	##       ##-
//	 4	##       ##-
//	 5	##       ##-
//	 6	##       ##-
//	 7	##       ##-
//	 8	##       ##-
//	 9	##       ##-
//	10	##       ##-
//	11	##       ##-
//	12	##       ##-
//	13	##       ##-
//	14	##      ###-
//	15	###########-
//	16	###########-
//	17	-#########--
//		000000000011
//		012345678901
const char chr233[]  = {0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x01,0x00,0x00,0x01,0x00,0x00,0x01,0x40,0x00,0x05};


//	 0	-####
//	 1	--###
//	 2	--###
//	 3	--###
//	 4	--###
//	 5	--###
//	 6	--####
//	 7	--####
//	 8	---###
//	 9	---###
//	10	---###
//	11	----###
//	12	----###
//	13	----####
//	14	-----####
//	15	------######
//	16	-------#####
//	17	--------####
//		000000000011
//		012345678901
const char chr234[]  = {0x40,0x2a,0xaa,0x50,0x2a,0xaa,0x50,0x2a,0xaa,0x50,0x2a,0xaa,0x50,0x2a,0xaa,0x50,0x2a,0xaa,0x50,0x0a,0xaa,0x50,0x0a,0xaa,0x54,0x0a,0xaa,0x54,0x0a,0xaa,0x54,0x0a,0xaa,0x55,0x02,0xaa,0x55,0x02,0xaa,0x55,0x00,0xaa,0x55,0x40,0x2a,0x55,0x50,0x00,0x55,0x54,0x00,0x55,0x55,0x00};


//	 0	##      ####
//	 1	##      ####
//	 2	##      ####
//	 3	##     #####
//	 4	#      #####
//	 5	#      #####
//	 6	       #####
//	 7	       #####
//	 8	      ###--#
//	 9	      ###--#
//	10	      ###--#
//	11	     ####--#
//	12	     ###----
//	13	    ####----
//	14	   ####-----
//	15	######------
//	16	#####-------
//	17	####--------
//		000000000011
//		012345678901
const char chr235[]  = {0x0a,0xaa,0x00,0x0a,0xaa,0x00,0x0a,0xaa,0x00,0x0a,0xa8,0x00,0x2a,0xa8,0x00,0x2a,0xa8,0x00,0xaa,0xa8,0x00,0xaa,0xa8,0x00,0xaa,0xa0,0x14,0xaa,0xa0,0x14,0xaa,0xa0,0x14,0xaa,0x80,0x14,0xaa,0x80,0x55,0xaa,0x00,0x55,0xa8,0x01,0x55,0x00,0x05,0x55,0x00,0x15,0x55,0x00,0x55,0x55};


//	 0	      ##
//	 1	      ##
//	 2	      ##
//	 3	      ##
//	 4	#     ##
//	 5	#
//	 6	#
//	 7	#
//	 8	#
//	 9	##
//	10	##
//	11	##
//	12	###
//	13	###
//	14	-####     ##
//	15	--##########
//	16	---#########
//	17	----########
//		000000000011
//		012345678901
const char chr236[]  = {0xaa,0xa0,0xaa,0xaa,0xa0,0xaa,0xaa,0xa0,0xaa,0xaa,0xa0,0xaa,0x2a,0xa0,0xaa,0x2a,0xaa,0xaa,0x2a,0xaa,0xaa,0x2a,0xaa,0xaa,0x2a,0xaa,0xaa,0x0a,0xaa,0xaa,0x0a,0xaa,0xaa,0x0a,0xaa,0xaa,0x02,0xaa,0xaa,0x02,0xaa,0xaa,0x40,0x2a,0xa0,0x50,0x00,0x00,0x54,0x00,0x00,0x55,0x00,0x00};


//	 0	   ###--##
//	 1	   ###--##
//	 2	   ###--##
//	 3	   ###--##
//	 4	  ####--##
//	 5	  ###---##
//	 6	  ###---##
//	 7	  ###---##
//	 8	  ###---##
//	 9	  ###---##
//	10	 ####---##
//	11	 ###----##
//	12	 ###----##
//	13	####----##
//	14	###-----###
//	15	##------####
//	16	#--------###
//	17	----------##
//		000000000011
//		012345678901
const char chr237[]  = {0xa8,0x05,0x0a,0xa8,0x05,0x0a,0xa8,0x05,0x0a,0xa8,0x05,0x0a,0xa0,0x05,0x0a,0xa0,0x15,0x0a,0xa0,0x15,0x0a,0xa0,0x15,0x0a,0xa0,0x15,0x0a,0xa0,0x15,0x0a,0x80,0x15,0x0a,0x80,0x55,0x0a,0x80,0x55,0x0a,0x00,0x55,0x0a,0x01,0x55,0x02,0x05,0x55,0x00,0x15,0x55,0x40,0x55,0x55,0x50};


//	 0	     ###----
//	 1	     ###----
//	 2	     ###----
//	 3	     ###----
//	 4	     ###----
//	 5	     ###----
//	 6	     ###----
//	 7	     ###----
//	 8	     ###----
//	 9	     ###----
//	10	     ###----
//	11	     ###----
//	12	     ###----
//	13	     ###----
//	14	    ####----
//	15	########----
//	16	########----
//	17	#######-----
//		000000000011
//		012345678901
const char chr238[]  = {0xaa,0x80,0x55,0xaa,0x80,0x55,0xaa,0x80,0x55,0xaa,0x80,0x55,0xaa,0x80,0x55,0xaa,0x80,0x55,0xaa,0x80,0x55,0xaa,0x80,0x55,0xaa,0x80,0x55,0xaa,0x80,0x55,0xaa,0x80,0x55,0xaa,0x80,0x55,0xaa,0x80,0x55,0xaa,0x80,0x55,0xaa,0x00,0x55,0x00,0x00,0x55,0x00,0x00,0x55,0x00,0x01,0x55};


//	 0	##       ##-
//	 1	##       ##-
//	 2	##       ##-
//	 3	##       ##-
//	 4	##       ##-
//	 5	##       ##-
//	 6	##       ##-
//	 7	##       ##-
//	 8	##       ##-
//	 9	##       ##-
//	10	##       ##-
//	11	##       ##-
//	12	##       ##-
//	13	##       ##-
//	14	##       ##-
//	15	###########-
//	16	-##########-
//	17	--########--
//		000000000011
//		012345678901
const char chr239[]  = {0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x0a,0xaa,0x81,0x00,0x00,0x01,0x40,0x00,0x01,0x50,0x00,0x05};


//	 0	---######---
//	 1	-###    ###-
//	 2	-#   ##   #-
//	 3	-# ###### #-
//	 4	-# ###### #-
//	 5	-# ###### #-
//	 6	-# ###### #-
//	 7	-# ###### #-
//	 8	-# ###### #-
//	 9	-# ###### #-
//	10	-# ###### #-
//	11	-# ###### #-
//	12	-# ###### #-
//	13	-# ###### #-
//	14	-# ###### #-
//	15	-# ###### #-
//	16	-#        #-
//	17	-##########-
//		000000000011
//		012345678901
const char chr240[]  = {0x54,0x00,0x15,0x40,0xaa,0x01,0x4a,0x82,0xa1,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x48,0x00,0x21,0x4a,0xaa,0xa1,0x40,0x00,0x01};


//	 0	------------
//	 1	-#########--
//	 2	#         #-
//	 3	-#########--
//	 4	----# #-----
//	 5	---#   #----
//	 6	--### ###---
//	 7	----# #-----
//	 8	----# #-----
//	 9	----# #-----
//	10	----# #-----
//	11	----# #-----
//	12	--### ###---
//	13	---#   #----
//	14	----# #-----
//	15	-#########--
//	16	#         #-
//	17	-#########--
//		000000000011
//		012345678901
const char chr241[]  = {0x55,0x55,0x55,0x40,0x00,0x05,0x2a,0xaa,0xa1,0x40,0x00,0x05,0x55,0x21,0x55,0x54,0xa8,0x55,0x50,0x20,0x15,0x55,0x21,0x55,0x55,0x21,0x55,0x55,0x21,0x55,0x55,0x21,0x55,0x55,0x21,0x55,0x50,0x20,0x15,0x54,0xa8,0x55,0x55,0x21,0x55,0x40,0x00,0x05,0x2a,0xaa,0xa1,0x40,0x00,0x05};

//	 0	------------
//	 1	----# #-----
//	 2	----# #-----
//	 3	----# #-----
//	 4	----# #-----
//	 5	----# #-----
//	 6	----# #-----
//	 7	----# #-----
//	 8	----# #-----
//	 9	----# ######
//	10	----#      #
//	11	-----#######
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr242[]  = {0x55,0x55,0x55,0x55,0x21,0x55,0x55,0x21,0x55,0x55,0x21,0x55,0x55,0x21,0x55,0x55,0x21,0x55,0x55,0x21,0x55,0x55,0x21,0x55,0x55,0x21,0x55,0x55,0x20,0x00,0x55,0x2a,0xa8,0x55,0x40,0x00,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----# #----
//	 2	-----# #----
//	 3	-----# #----
//	 4	-----# #----
//	 5	-----# #----
//	 6	-----# #----
//	 7	-----# #----
//	 8	-----# #----
//	 9	###### #----
//	10	#      #----
//	11	#######-----
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr243[]  = {0x55,0x55,0x55,0x55,0x48,0x55,0x55,0x48,0x55,0x55,0x48,0x55,0x55,0x48,0x55,0x55,0x48,0x55,0x55,0x48,0x55,0x55,0x48,0x55,0x55,0x48,0x55,0x00,0x08,0x55,0x2a,0xa8,0x55,0x00,0x01,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	###########-
//	 2	           #
//	 3	# ######## #
//	 4	# # #--# # #
//	 5	# #  #-# # #
//	 6	# #   ## # #
//	 7	# #    # # #
//	 8	# #      # #
//	 9	# #      # #
//	10	# #    # # #
//	11	# #   ## # #
//	12	# #  #-# # #
//	13	# # #--# # #
//	14	# ######## #
//	15	           #
//	16	###########-
//	17	------------
//		000000000011
//		012345678901
const char chr244[]  = {0x55,0x55,0x55,0x00,0x00,0x01,0xaa,0xaa,0xa8,0x20,0x00,0x08,0x22,0x14,0x88,0x22,0x84,0x88,0x22,0xa0,0x88,0x22,0xa8,0x88,0x22,0xaa,0x88,0x22,0xaa,0x88,0x22,0xa8,0x88,0x22,0xa0,0x88,0x22,0x84,0x88,0x22,0x14,0x88,0x20,0x00,0x08,0xaa,0xaa,0xa8,0x00,0x00,0x01,0x55,0x55,0x55};


//	 0	------------
//	 1	----------#
//	 2	------##--#
//	 3	-----#  #-##
//	 4	-----#  ##
//	 5	------###
//	 6	-------#  ##
//	 7	----###  #--
//	 8	---#  #  #--
//	 9	---#  #  #--
//	10	----###  #--
//	11	-------#  ##
//	12	------###
//	13	-----#  ##
//	14	-----#  #-##
//	15	------##--#
//	16	----------#
//	17	----------##
//		000000000011
//		012345678901
const char chr245[]  = {0x55,0x55,0x55,0x55,0x55,0x52,0x55,0x50,0x52,0x55,0x4a,0x10,0x55,0x4a,0x0a,0x55,0x50,0x2a,0x55,0x54,0xa0,0x55,0x02,0x85,0x54,0xa2,0x85,0x54,0xa2,0x85,0x55,0x02,0x85,0x55,0x54,0xa0,0x55,0x50,0x2a,0x55,0x4a,0x0a,0x55,0x4a,0x10,0x55,0x50,0x52,0x55,0x55,0x52,0x55,0x55,0x50};

//	 0	-----##-----
//	 1	----#  #----
//	 2	---#    #---
//	 3	--#      #--
//	 4	--###  ###--
//	 5	----#  #----
//	 6	----#  #----
//	 7	############
//	 8
//	 9
//	10	############
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr246[] = {0x55,0x41,0x55,0x55,0x28,0x55,0x54,0xaa,0x15,0x52,0xaa,0x85,0x50,0x28,0x05,0x55,0x28,0x55,0x55,0x28,0x55,0x00,0x00,0x00,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0x00,0x00,0x00,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	-----##-----
//	 2	----#  #----
//	 3	---#    #---
//	 4	--#      #--
//	 5	--###  ###--
//	 6	----#  #----
//	 7	############
//	 8
//	 9
//	10	############
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr247[] = {0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x54,0xaa,0x15,0x52,0xaa,0x85,0x50,0x28,0x05,0x55,0x28,0x55,0x00,0x00,0x00,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0x00,0x00,0x00,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	-----##-----
//	 4	----#  #----
//	 5	---#    #---
//	 6	--#      #--
//	 7	############
//	 8
//	 9
//	10	############
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr248[] = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x54,0xaa,0x15,0x52,0xaa,0x85,0x00,0x00,0x00,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0x00,0x00,0x00,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	-----##-----
//	 5	----#  #----
//	 6	---#    #---
//	 7	############
//	 8
//	 9
//	10	############
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr249[] = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x41,0x55,0x55,0x28,0x55,0x54,0xaa,0x15,0x00,0x00,0x00,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0x00,0x00,0x00,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	############
//	 8
//	 9
//	10	############
//	11	------------
//	12	------------
//	13	------------
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr250[] = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x00,0x00,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0x00,0x00,0x00,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	############
//	 8
//	 9
//	10	############
//	11	---#    #---
//	12	----#  #----
//	13	-----##-----
//	14	------------
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr251[] = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x00,0x00,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0x00,0x00,0x00,0x54,0xaa,0x15,0x55,0x28,0x55,0x55,0x41,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	############
//	 8
//	 9
//	10	############
//	11	--#      #--
//	12	---#    #---
//	13	----#  #----
//	14	-----##-----
//	15	------------
//	16	------------
//	17	------------
//		000000000011
//		012345678901
const char chr252[] = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x00,0x00,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0x00,0x00,0x00,0x52,0xaa,0x85,0x54,0xaa,0x15,0x55,0x28,0x55,0x55,0x41,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	############
//	 8
//	 9
//	10	############
//	11	----#  #----
//	12	--###  ###--
//	13	--#      #--
//	14	---#    #---
//	15	----#  #----
//	16	-----##-----
//	17	------------
//		000000000011
//		012345678901
const char chr253[] = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x00,0x00,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0x00,0x00,0x00,0x55,0x28,0x55,0x50,0x28,0x05,0x52,0xaa,0x85,0x54,0xaa,0x15,0x55,0x28,0x55,0x55,0x41,0x55,0x55,0x55,0x55};


//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	############
//	 8
//	 9
//	10	############
//	11	----#  #----
//	12	----#  #----
//	13	--###  ###--
//	14	--#      #--
//	15	---#    #---
//	16	----#  #----
//	17	-----##-----
//		000000000011
//		012345678901
const char chr254[]  = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x00,0x00,0x00,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0x00,0x00,0x00,0x55,0x28,0x55,0x55,0x28,0x55,0x50,0x28,0x05,0x52,0xaa,0x85,0x54,0xaa,0x15,0x55,0x28,0x55,0x55,0x41,0x55};

//	 0	------------
//	 1	------------
//	 2	------------
//	 3	------------
//	 4	------------
//	 5	------------
//	 6	------------
//	 7	------------
//	 8	--  ---- ---
//	 9	- ## -- # --
//	10	 #  #  # # -
//	11	 #  # # # --
//	12	- ## # # ---
//	13	--  # #  ---
//	14	-- # # ## --
//	15	- # # #  # -
//	16	 # #  #  # -
//	17	- # -- ## --
//		000000000011
//		012345678901
const char chr255[] = {0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x5a,0x55,0x95,0x60,0x96,0x25,0x8a,0x28,0x89,0x8a,0x22,0x25,0x60,0x88,0x95,0x5a,0x22,0x95,0x58,0x88,0x25,0x62,0x22,0x89,0x88,0xa2,0x89,0x62,0x58,0x25};


const char *chars[]   = { chr0, chr1, chr2, chr3, chr4, chr5, chr6, chr7, chr8, chr9, chr10, chr11, chr12, chr13, chr14, chr15, chr16, chr17, chr18, chr19, chr20, chr21, chr22, chr23, chr24, chr25, chr26, chr27, chr28, chr29, chr30, chr31, chr32, chr33, chr34, chr35, chr36, chr37, chr38, chr39, chr40, chr41, chr42, chr43, chr44, chr45, chr46, chr47, chr48, chr49, chr50, chr51, chr52, chr53, chr54, chr55, chr56, chr57, chr58, chr59, chr60, chr61, chr62, chr63, chr64, chr65, chr66, chr67, chr68, chr69, chr70, chr71, chr72, chr73, chr74, chr75, chr76, chr77, chr78, chr79, chr80, chr81, chr82, chr83, chr84, chr85, chr86, chr87, chr88, chr89, chr90, chr91, chr92, chr93, chr94, chr95, chr96, chr97, chr98, chr99, chr100, chr101, chr102, chr103, chr104, chr105, chr106, chr107, chr108, chr109, chr110, chr111, chr112, chr113, chr114, chr115, chr116, chr117, chr118, chr119, chr120, chr121, chr122, chr123, chr124, chr125, chr126, chr127, chr128, chr129, chr130, chr131, chr132, chr133, 
chr134, chr135, chr136, chr137, chr138, chr139, chr140, chr141, chr142, chr143, chr144, chr145, chr146, chr147, chr148, chr149, 
chr150, chr151, chr152, chr153, chr154, chr155, chr156, chr157, chr158, chr159, chr160, chr161, chr162, chr163, chr164, chr165,
 chr166, chr167, chr168, chr169, chr170, chr171, chr172, chr173, chr174, chr175, chr176, chr177, chr178, chr179, chr180, chr181,
  chr182, chr183, chr184, chr185, chr186, chr187, chr188, chr189, chr190, chr191, chr192, chr193, chr194, chr195, chr196, chr197, 
  chr198, chr199, chr200, chr201, chr202, chr203, chr204, chr205, chr206, chr207, chr208, chr209, chr210, chr211, chr212, chr213, 
  chr214, chr215, chr216, chr217, chr218, chr219, chr220, chr221, chr222, chr223, chr224, chr225, chr226, chr227, chr228, chr229, 
  chr230, chr231, chr232, chr233, chr234, chr235, chr236, chr237, chr238, chr239, chr240, chr241, chr242, chr243, chr244, chr245,
   chr246, chr247, chr248, chr249, chr250, chr251, chr252, chr253, chr254, chr255};
